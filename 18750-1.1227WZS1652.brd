# Allegro board 18750-1.1227WZS1652.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EDP_TX_CPU_P1: length 231.7
  L6 w0.102: v1(111.16,127.16) 111.13,127.46 111.13,127.46 111.22,127.58 111.65,127.58 112.55,126.67 115.34,126.67 116.43,125.58 117.76,125.58 120.88,122.46 120.88,121.72 123.18,119.43 123.18,117.9 125.93,115.15 125.93,113.97 127.84,112.06 127.84,110.29 129.09,109.04 129.09,105.86 129.95,105 129.95,101.93 129.44,101.42 129.44,94.36 129.92,93.87 129.92,89.89 130.38,89.44 130.38,75.95 132.18,74.14 159.79,74.14 161.34,72.59 164.28,72.59 165.15,71.73 172.87,71.73 173.73,70.87 176.57,70.87 177.08,70.36 177.95,70.36 178.51,69.8 179.18,69.8 182.22,66.76 182.22,64.35 185.03,61.54 188.5,61.54 190.33,63.37 198.55,63.37 200.61,65.43 210.48,65.43 210.64,65.43 211.99,66.78 221.41,66.78 223.85,64.34 223.85,56.14 221.08,53.37 215.56,53.37 214.53,52.33 214.27,52.33 213.91,52.69 213.75,52.69 v1(213.59,52.53)
  BOTTOM w0.076: 85.79,108.19 85.78,108.18 85.78,108.14 84.72,107.08 84.72,106.8 84.58,106.66 CPU1.AG1
  BOTTOM w0.114: 111.15,126.24 109.25,126.24 106.04,123.03 93.16,123.03 86.44,116.31 86.44,108.83 85.79,108.19 ; 111.15,126.24 111.92,126.24 112.19,126.52 112.19,127.01 111.64,127.56 111.3,127.56 111.17,127.43 111.17,127.16 v1(111.16,127.16) ; 111.15,126.24 v2(111.15,126.39) ; C5522.1 214.43,52.38 214.25,52.38 213.94,52.69 213.75,52.69 v1(213.59,52.53)
EDP_VDD_EN: length 93.5
  TOP w0.089: D5502.1 156.28,77.74 153.47,74.93 153.47,68.33 155.91,65.89 v1(155.93,65.89)
  L3 w0.089: v1(121.59,99.24) 121.51,99.33 119.54,99.33 119.48,99.27 114.59,99.27 114.25,99.61 109.13,99.61 v1(108.68,100.06)
  L6 w0.089: v1(121.59,99.24) 121.97,98.86 121.97,91.41 123.52,89.85 123.52,82.22 121.88,80.58 121.88,79.1 123.32,77.66 123.32,72.22 123.37,72.17 123.37,72.1 126.13,69.34 128.22,69.34 130.91,66.65 131.21,66.65 155.17,66.65 v1(155.93,65.89)
  BOTTOM w0.089: CPU1.CG11 v1(108.68,100.06) ; v2(121.01,99.24) v1(121.59,99.24)
EMMC_RCOMP: length 9.6
  BOTTOM w0.076: 114.29,96.73 112.3,96.73 112.17,96.81 111.89,97.09 111.89,97.24 111.67,97.46 CPU1.CK15
  BOTTOM w0.127: R2108.1 118.48,93.71 118.27,93.93 117.07,93.93 v2(115.55,95.45) 115,96 115,96.03 114.29,96.73
EQ0: length 3.3
  TOP w0.089: U7101.38 v1(19.31,104.39)
  BOTTOM w0.089: R7143.1 20.35,104.73 20.09,104.98 v2(19.54,104.98) 19.31,104.75 v1(19.31,104.39) 19.03,104.12 R7142.2
EQ1: length 3.5
  TOP w0.089: U7101.35 v1(19.31,105.59) 19.3,105.59 19.3,105.59 19.04,105.59 v2(18.8,105.35)
  BOTTOM w0.089: R7141.1 20.19,105.59 v1(19.31,105.59) 18.65,104.93 R7140.2
ESPI_ALERT#: length 38.5
  TOP w0.114: v1(127.51,75.79) 127.87,75.79 v2(128.65,75.01) 128.65,74.27 130.33,72.59 R1821.2
  L3 w0.089: v1(127.51,75.79) 126.6,75.79 122.61,79.78 121.18,79.78 119.89,78.5 118.11,78.5 117.17,79.44 117.17,82.1 114.26,85.02 108.38,85.02 108.08,84.71 107.24,84.71 106.02,85.93 105.08,85.93 104.88,86.13 104.88,87.71 104.88,88.7 104.48,89.11 v1(104.48,89.16)
  BOTTOM w0.114: v1(104.48,89.16) 104.45,89.16 104.44,89.16 104.29,89.16 CPU1.BV28
ESPI_CLK: length 114.6
  TOP w0.114: DBG1.2 40.61,53.78 40.52,53.87 EC1801.1 39.86,54.58 39.68,54.76 39.21,54.76 39.09,54.65 v2(39.09,54.59) 39.09,52.53 39.09,52.53 39.09,50.82 38.99,50.72 38.99,50.67 38.69,50.37 32.52,50.37 32.09,50.8 32.09,52.53 32.08,52.54 32.08,53.61 32.69,54.22 34.22,54.22 34.9,54.89 34.9,57.08 34.75,57.22 U2401.57 34.75,59.62 32.86,61.51 32.86,67.13 35,69.26 v1(35,69.79) ; v1(60.2,73.33) 62.92,73.33 65.61,70.65 102.04,70.65 103.79,72.39 R1805.2
  BOTTOM w0.114: v1(35,69.79) 35.78,70.58 38.23,70.58 39.38,71.72 47.34,71.72 48,71.07 48.99,71.07 49.19,70.87 50.84,70.87 51.05,70.66 52.73,70.66 54.84,72.77 57.56,72.77 58.12,73.33 v1(60.2,73.33)
ESPI_CS#: length 118.9
  TOP w0.089: v1(106.3,89.17) 106.51,89.17 106.75,88.93 106.75,88.29 107.61,87.43 107.61,86.31 106.84,85.53
  TOP w0.114: v1(33.86,67.26) 33.21,66.61 33.21,61.65 35.15,59.7 U2401.58 35.15,57.51 35.24,57.42 35.24,54.75 33.12,52.63 33.12,52.53 33.12,52.53 33.12,50.82 33.22,50.72 37.36,50.72 37.61,50.96 DBG1.5 ; v1(59.83,70.65) 59.88,70.65 v2(60.3,70.23) 61.22,69.32 102.56,69.32 106.84,73.59 106.84,85.53
  BOTTOM w0.114: v1(106.3,89.17) 106.28,89.17 CPU1.CA28 ; v1(33.86,67.26) 34.01,67.11 34.64,67.11 35.12,67.6 35.12,68 35.64,68.52 38.52,68.52 40.09,70.09 45.41,70.09 46.59,68.91 53.67,68.91 55.41,70.64 59.13,70.64 59.13,70.65 v1(59.83,70.65)
ESPI_IO0: length 96.8
  TOP w0.114: v1(34.46,67.55) 34.31,67.4 34.31,67 33.45,66.14 33.45,61.75 35.55,59.64 U2401.59 35.55,54.72 33.61,52.77 DBG1.9 ; RN1806.8 106.33,73.42 102.46,69.56 61.8,69.56 v2(61.47,69.89) 60.2,71.16 60.2,71.17 60.07,71.3 v1(59.83,71.3)
  BOTTOM w0.114: v1(59.83,71.3) 59.44,71.3 59.03,70.89 55.29,70.89 53.55,69.15 46.71,69.15 45.53,70.33 39.99,70.33 38.42,68.76 35.54,68.76 34.46,67.68 v1(34.46,67.55)
ESPI_IO1: length 96.9
  TOP w0.114: DBG1.8 34.61,53.39 35.95,54.74 v2(35.95,55.78) U2401.60 35.95,59.58 33.69,61.85 33.69,66.04 34.9,67.25 34.9,68.45 35.63,69.18 v1(35.63,69.79) ; RN1806.6 105.24,73.02 102.26,70.04 63.4,70.04 61.25,72.19 60.49,72.19 60.42,72.26 60.02,72.26 60.01,72.27 59.99,72.27 v1(59.57,72.7)
  BOTTOM w0.114: v1(59.57,72.7) 59.13,72.26 54.84,72.26 52.89,70.31 50.91,70.31 50.7,70.52 49.04,70.52 48.85,70.72 47.86,70.72 47.2,71.38 39.52,71.38 38.38,70.24 36.08,70.24 v1(35.63,69.79)
ESPI_IO2: length 96.8
  TOP w0.114: v1(60.21,71.81) 60.81,71.81 62.82,69.8 102.36,69.8 105.74,73.18 RN1806.7 ; v1(35.56,67.82) 35.56,67.57 33.93,65.94 33.93,61.95 36.35,59.52 U2401.61 36.35,54.59 v2(36.07,54.3) 35.61,53.84 DBG1.7
  BOTTOM w0.114: v1(60.21,71.81) 60.61,71.41 60.61,70.79 58.25,68.44 43.99,68.44 42.58,69.84 40.19,69.84 38.62,68.28 36.02,68.28 v1(35.56,67.82)
ESPI_IO3: length 96.9
  TOP w0.114: v1(36.27,67.82) 36.29,67.81 36.29,67.63 34.17,65.51 34.17,62.05 36.75,59.47 U2401.62 36.75,54.48 36.61,54.34 DBG1.6 ; RN1806.5 104.65,72.77 102.16,70.28 64.62,70.28 v2(63.8,71.1) 62.21,72.69 60.21,72.69 v1(60.2,72.7)
  BOTTOM w0.114: v1(60.2,72.7) 60.2,72.48 60.85,71.83 60.85,70.69 58.33,68.17 43.87,68.17 42.44,69.6 40.47,69.6 38.25,67.38 37.58,67.38 37.14,67.82 v1(36.27,67.82)
ESPI_RESET#: length 131.1
  TOP w0.114: U2401.53 33.15,60.35 32.19,61.31 32.19,65.51 31.82,65.88 31.82,66.72 33.28,68.17 33.28,68.69 34.82,70.23 36.7,70.23 v1(37.13,69.8) ; v1(59.57,72.06) 59.39,71.88 59.39,70.48 60.79,69.08 102.66,69.08 107.08,73.49 107.08,80.88 108.54,82.35 108.54,89.33 107.7,90.17 106.67,90.17 v1(106.3,89.81) ; DBG1.4 38.61,54.66 39.5,55.55 v2(39.5,55.75) v1(39.5,59.49)
  L3 w0.089: v1(39.5,59.49) 39.07,59.92 39.07,67.86 v1(37.13,69.8)
  BOTTOM w0.114: v1(37.13,69.8) 38.31,69.8 39.65,71.14 47.1,71.14 47.76,70.48 48.75,70.48 48.94,70.28 50.6,70.28 50.81,70.07 53.01,70.07 54.82,71.89 59.39,71.89 v1(59.57,72.06) ; CPU1.CA27 106.28,89.81 v1(106.3,89.81)
EXT_PWR_GATE#: length 120.9
  TOP w0.089: v1(149.21,65.03) 144.88,65.03 142.54,67.37 134.56,67.37 v2(133.1,68.84) 132.97,68.96 v1(132.97,69.52)
  L6 w0.089: v1(149.21,65.03) 148.67,64.49 130.79,64.49 127.48,67.8 125,67.8 117.54,75.26 117.54,84.74 119.67,86.87 120.78,86.87 121.21,87.29 121.21,87.71 120.96,87.96 120.75,87.96 120.4,88.32 120.4,88.65 120.02,89.02 120.02,90.13 119.69,90.46 119.69,95.73 119.36,96.06 119.36,98.77 119.9,99.3 119.9,99.96 v1(120.78,100.84)
  BOTTOM w0.089: v1(132.97,69.52) 120.02,69.52 117.8,71.74 117.43,72.11 114.51,72.11 112.25,72.11 107.57,76.79 107.57,80.31 107.57,80.89 107.17,81.29 107.17,82.17 106.99,82.35 CPU1.CC37 ; 121.67,100.13 120.96,100.84 v1(120.78,100.84)
FALL_INT2: length 3.4
  TOP w0.089: Q7001.2 137.01,96.42 R7010.2 ; Q7001.3 136.36,95.84 136.93,96.42 R7010.2 ; R7010.2 137.56,96.42 v2(137.87,96.72)
FAN1_PWM: length 258.8
  TOP w0.127: v1(169.6,75.23) 169.6,72.11 170.92,70.79 170.92,68.9 171.55,68.27 171.55,64.46 170.66,63.57 170.66,62.59 170.35,62.28 v1(170.28,62.28) 170.28,62.26 v2(170.67,61.87) ; EC2601.1 30.61,57.84 30.76,57.98 U2401.47 30.76,61.27 v1(29.59,62.43) ; R2614.1 159.72,84.46 v1(160.96,85.7)
  L5 w0.127: v1(169.6,75.23) 168.13,75.23 164.98,78.37 163.94,78.37 162.25,80.06 162.25,84.41 v1(160.96,85.7)
  L6 w0.127: v1(29.59,62.43) 29.14,61.98 29.14,60.3 27.55,58.71 25.11,58.71 23.79,57.39 23.79,57.04 22.69,55.93 22.69,51.03 21.82,50.16 21.82,43.34 22.36,42.79 22.36,38.25 25.25,35.35 31.14,35.35 32.31,36.52 33.63,36.52 34.48,37.38 34.48,42.48 35.68,43.67 60.05,43.67 61.04,42.69 65.95,42.69 67.19,41.45 67.19,41.38 68.32,40.25 90.47,40.25 90.88,40.67 93.63,40.67 93.94,40.36 103.55,40.36 104.04,40.84 105.38,40.84 107.78,43.23 109.75,43.23 111.28,44.76 126.21,44.76 128.96,42.01 130.51,42.01 130.64,41.88 130.64,41.54 130.77,41.41 130.77,40.39 130.9,40.27 139.28,40.27 141.44,42.43 143.47,42.43 143.73,42.17 143.73,41.77 147.26,38.24 152.04,38.24 152.54,38.75 156.28,38.75 156.87,39.33 167.37,39.33 169.22,41.18 169.78,41.18 172.24,43.65 172.24,51.33 172.76,51.86 172.76,52.62 172.49,52.88 172.49,59.75 170.28,61.96 v1(170.28,62.28)
  BOTTOM w0.127: v1(160.96,85.7) 160.96,85.7 RN2601.3
FAN1_TACH: length 3.6
  TOP w0.127: U2401.40 27.95,57.85 27.61,57.51 R2430.1 27.59,57.3 D2403.A 27,56.24 26.8,56.44 v2(26.67,56.44)
FAN_PWM1_C: length 3.3
  TOP w0.127: AFTP2602.1 158.91,85.32 R2614.2 159.69,85.32 v1(160.07,85.7)
  BOTTOM w0.127: FAN1.4 v1(160.07,85.7)
FAN_TACH1: length 293.4
  TOP w0.127: v1(160.96,86.36) 160.81,86.21 159.49,86.21 R2613.1 ; D2403.K 27.59,53.37 EC2602.1 28.03,52.62 28.03,50.71 30.48,48.26 30.48,47.02 30.48,47.02 30.48,46.53 30.38,46.43 30.38,46.43 30.11,46.16 30.11,45.48 29.76,45.12 29.4,45.12 28.25,46.28 26.76,46.28 26.57,46.1 26.57,41.71 25.55,40.68 25.55,37.02 25.42,36.89 22.46,36.89 21.03,35.47 21.03,33.65 18.12,30.74 16.52,30.74 16.31,30.74 14.96,29.39 14.96,25.16 13.78,23.99 13.78,23.62 13.83,23.57 13.83,22.95 v1(13.36,22.48) ; v1(170.22,62.92) 170.22,63.49 171.28,64.54 171.28,68.19 170.67,68.8 170.67,70.69 169.35,72 169.35,73.68 169.14,73.89 169.14,75.64 v1(169.27,75.77) ; v1(110.16,32.28) v2(110.9,32.28)
  L5 w0.127: v1(160.96,86.36) 162.51,84.81 162.51,80.16 164.05,78.63 165.14,78.63 168,75.77 v1(169.27,75.77) ; v1(13.36,22.48) 13.91,23.03 13.91,23.1 14.17,23.36 14.41,23.36 14.45,23.39 19.99,23.39 20.7,22.69 21.64,22.69 25.39,18.94 29.75,18.94 30.05,19.24 32.02,19.24 33.23,20.44 33.54,20.44 34.9,21.8 34.9,22.01 40.67,27.79 45.77,27.79 46.25,28.27 89.81,28.27 91.31,29.77 93.96,29.77 94.62,29.11 106.28,29.11 108.64,31.47 109.79,31.47 110.16,31.84 v1(110.16,32.28)
  L6 w0.127: v1(170.22,62.92) 169.84,62.54 169.84,62.02 172.21,59.65 172.21,53.92 171.87,53.58 171.87,43.64 169.67,41.44 169.12,41.44 168.58,40.9 157.32,40.9 155.42,39 152.44,39 151.93,38.49 147.39,38.49 146.1,39.78 146.1,41.79 145.12,42.77 129.12,42.77 126.48,45.41 111.01,45.41 109.55,43.94 107.27,43.94 v1(106.18,42.85)
  BOTTOM w0.127: v1(110.16,32.28) 108.81,33.64 108.81,38.06 108.52,38.35 108.52,38.96 108.09,39.39 108.09,40.92 107.17,41.83 106.64,41.83 106.18,42.3 v1(106.18,42.85) ; RN2601.4 161.63,83.56 161.24,83.95 161.24,85.35 161.41,85.52 161.41,85.92 v1(160.96,86.36)
FAN_TACH1_C: length 3.2
  TOP w0.127: v1(160.07,86.7) 159.78,87 R2613.2 158.68,87 AFTP2601.1
  BOTTOM w0.127: v1(160.07,86.7) FAN1.3
FB_CAL_PD_VDDQ: length 16.6
  TOP w0.254: R7805.1 150.6,118.09 v2(149.79,118.09) 149.18,118.09 147.07,120.19 147.07,126.42 145.29,128.2 145.29,130.19 144.71,130.77 v1(144.66,130.77)
  BOTTOM w0.356: v1(144.66,130.77) GPU1.D22
FB_CAL_PU_GND: length 16
  TOP w0.254: R7807.1 149.05,118.87 v2(148.94,118.99) 147.45,120.47 147.45,127.05 147.04,127.46 147.04,128.75 146.71,129.08 146.21,129.08 145.86,129.43 v1(145.86,130.84)
  BOTTOM w0.356: GPU1.C24 145.88,130.86 v1(145.86,130.84)
FB_CAL_TERM_GND: length 14.7
  TOP w0.254: R7806.1 149.15,119.97 149.15,120.74 149.2,120.8 v2(149.2,121.08) 148.72,121.08 147.91,121.9 147.91,127.36 147.58,127.69 147.58,128.17 148.03,128.63 148.57,128.63 148.87,128.93 148.87,130.46 v1(148.72,130.61)
  BOTTOM w0.152: GPU1.B25 147.58,131.41 148.15,130.84 148.22,130.84 148.45,130.61 v1(148.72,130.61)
FB_CLAM: length 5.1
  BOTTOM w0.254: v2(129.44,118.19) R7818.1 129.24,119.25 130.78,119.25 131.81,120.28 GPU1.F3
FBA0_VREFC: length 6.7
  BOTTOM w0.305: 161.03,116.29 160.4,116.92 VRAM1.J14
  BOTTOM w0.508: v2(164.99,114.23) 164.93,114.29 R8101.2 164.46,115.58 C8136.1 163.41,115.58 R8103.1 R8102.2 161.75,115.57 161.03,116.29
FBA1_VREFC: length 53.5
  TOP w0.508: v1(167.03,133.81) 167.39,133.45 167.39,131.75 167.9,131.24 167.9,128.2 168,128.09 168,123.01 167.59,122.61 167.59,121.77 167.9,121.46 167.9,113.84 v1(167.06,113.01)
  L5 w0.508: v1(160.56,153.47) 160.56,153.19 162.31,151.44 167.01,151.44 167.9,150.55 167.9,135 167.03,134.14 v1(167.03,133.81)
  BOTTOM w0.356: C8140.1 160.35,151.51 160.79,151.08 R8104.2 160.79,150.23 160.4,149.85 VRAM4.J14
  BOTTOM w0.508: v2(167.62,113.01) v1(167.06,113.01) R8105.2 ; v1(160.56,153.47) 160.35,153.26 R8106.1 C8140.1
FBA_CLK0_MIDPT: length 1.5
  TOP w0.14: R8113.2 R8114.2 152.71,119.71 C8142.1
FBA_CLK0N: length 31.1
  TOP w0.14: v1(146.44,132.55) 146.75,132.24 147.13,132.24 148.13,133.24 149.03,133.24 149.55,132.73 149.55,126.49 149.25,126.19 149.1,126.19 148.96,126.05 148.96,125.77 149.1,125.63 149.25,125.63 149.55,125.34 149.55,124.84 149.25,124.54 149.1,124.54 148.96,124.4 148.96,124.12 149.1,123.98 149.25,123.98 149.55,123.69 149.55,121.86 150.12,121.29 150.44,121.29 v1(150.66,121.5) 151.02,121.14 151.78,121.14 R8113.1
  L3 w0.102: v1(150.66,121.5) 150.87,121.29 153.12,121.29 153.56,120.85 159.54,120.85 160.42,119.96 160.42,119.81 v1(160.8,119.43)
  BOTTOM w0.14: v1(160.8,119.43) VRAM1.J11 ; v1(146.44,132.55) 146.43,132.54 GPU1.D25
FBA_CLK0P: length 31.1
  TOP w0.14: R8114.1 151.41,120.88 150.69,120.88 v1(150.66,120.85) 150.49,121.02 150.01,121.02 149.28,121.75 149.28,123.57 149.14,123.71 148.99,123.71 148.69,124.01 148.69,124.51 148.99,124.81 149.14,124.81 149.28,124.95 149.28,125.23 149.14,125.37 148.99,125.37 148.69,125.66 148.69,126.16 148.99,126.46 149.14,126.46 149.28,126.6 149.28,132.62 148.92,132.97 148.24,132.97 147.24,131.97 v1(145.86,131.97)
  L3 w0.102: v1(150.66,120.85) 150.9,121.09 153.03,121.09 153.48,120.64 159.45,120.64 160.22,119.88 160.22,119.65 v1(160,119.43)
  BOTTOM w0.14: v1(160,119.43) VRAM1.J12 ; GPU1.D24 145.86,131.98 v1(145.86,131.97)
FBA_CLK1_MIDPT: length 1.8
  BOTTOM w0.14: R8116.2 R8115.2 151.18,144.17 C8141.1
FBA_CLK1N: length 36.1
  TOP w0.089: 142.69,138.99 142.69,138.97 142.65,138.93 142.65,138.36 140.82,136.54 140.32,136.54 139.64,135.86 139.64,135.59 139.44,135.39 v1(139.44,134.98)
  TOP w0.14: 142.69,138.99 142.69,140.31 146.19,143.81 147.42,143.81 148.37,144.77 149.2,144.77 v1(149.4,144.56)
  L6 w0.102: v1(160.8,147.33) 160.64,147.17 160.64,146.28 159.85,145.49 159.85,145.3 159.33,144.79 155.32,144.79 155.22,144.69 155.22,144.21 155,143.99 154.55,143.99 154.33,144.21 154.33,144.69 154.23,144.79 153.95,144.79 153.85,144.69 153.85,144.14 153.63,143.92 153.18,143.92 152.96,144.14 152.96,144.69 152.86,144.79 152.58,144.79 152.48,144.69 152.48,144.14 152.25,143.92 151.81,143.92 151.59,144.14 151.59,144.69 151.48,144.79 151.21,144.79 151.1,144.69 151.1,144.14 150.88,143.92 150.44,143.92 150.21,144.14 150.21,144.69 150.11,144.79 149.63,144.79 v1(149.4,144.56)
  BOTTOM w0.114: v1(139.44,134.98) GPU1.M22
  BOTTOM w0.14: v1(160.8,147.33) VRAM4.J11 ; v1(149.4,144.56) R8115.1
FBA_CLK1P: length 36.2
  TOP w0.089: 142.42,138.99 142.42,138.97 142.46,138.93 142.46,138.44 140.75,136.73 140.24,136.73 139.45,135.94 139.45,135.67 139.32,135.54 v1(138.88,135.54)
  TOP w0.14: v1(149.43,145.19) 149.27,145.03 148.26,145.03 147.31,144.08 146.08,144.08 142.42,140.42 142.42,138.99
  L6 w0.102: v1(149.43,145.19) 149.63,144.99 150.2,144.99 150.42,144.77 150.42,144.22 150.52,144.12 150.8,144.12 150.9,144.22 150.9,144.77 151.12,144.99 151.57,144.99 151.79,144.77 151.79,144.22 151.89,144.12 152.17,144.12 152.27,144.22 152.27,144.77 152.49,144.99 152.94,144.99 153.16,144.77 153.16,144.22 153.26,144.12 153.54,144.12 153.64,144.22 153.64,144.77 153.86,144.99 154.31,144.99 154.53,144.77 154.53,144.3 154.63,144.2 154.91,144.2 155.02,144.3 155.02,144.77 155.24,144.99 159.25,144.99 159.65,145.39 159.65,145.57 160.44,146.36 160.44,146.89 v1(160,147.33)
  BOTTOM w0.114: v1(138.88,135.54) GPU1.N22
  BOTTOM w0.14: v1(160,147.33) VRAM4.J12 ; R8116.1 150.29,145.06 149.56,145.06 v1(149.43,145.19)
FBA_CMD0: length 23.8
  BOTTOM w0.14: VRAM1.G12 158.37,119.46 158.37,121.48 158.12,121.73 153.5,121.73 153.24,121.47 152.78,121.47 152.32,121.47 149.58,124.2 149.48,124.3 149.48,132.63 148.51,133.6 147.98,133.6 147.58,133.2 GPU1.C27
FBA_CMD1: length 24.3
  BOTTOM w0.14: GPU1.C26 147.01,133.09 147.88,133.96 148.7,133.96 150.14,132.51 150.14,124.43 152.55,122.03 153.24,122.03 153.25,122.03 158.97,122.03 159.73,121.27 159.73,120.76 VRAM1.H10
FBA_CMD2: length 27.1
  TOP w0.14: v1(159.2,120.23) 159.24,120.27 159.24,121.56 158.95,121.85 152.37,121.85 150.35,123.88 150.35,123.91 150.33,123.93 150.33,132.77 149.44,133.66 147.58,133.66 146.99,133.07 146.35,133.07 145.86,132.58 v1(145.28,132.58)
  BOTTOM w0.14: VRAM1.H11 v1(159.2,120.23) ; v1(145.28,132.58) 144.71,132.58 GPU1.E24
FBA_CMD3: length 30.2
  TOP w0.14: v1(160.8,120.23) 160.85,120.28 160.85,121.31 159.94,122.23 152.82,122.23 150.89,124.16 150.89,133 149.71,134.18 147.21,134.18 146.94,133.91 145.94,133.91 144.58,132.55 v1(144.12,132.55)
  BOTTOM w0.14: GPU1.F24 144.11,132.55 v1(144.12,132.55) ; VRAM1.K11 v1(160.8,120.23)
FBA_CMD4: length 25.2
  BOTTOM w0.14: VRAM1.K10 161.28,120.71 161.28,121.16 160.96,121.48 160.01,122.43 153.41,122.43 153.24,122.59 152.78,122.59 150.73,124.64 150.73,132.56 148.9,134.39 148.61,134.39 147.72,134.39 GPU1.D27
FBA_CMD5: length 29.1
  BOTTOM w0.14: GPU1.D26 146.44,133.62 146.89,134.07 147.05,134.07 147.79,134.81 149.09,134.81 151.41,132.49 151.41,124.75 153.01,123.15 153.24,123.15 153.55,122.85 160.52,122.85 161.78,121.6 161.78,120.9 161.62,120.75 161.62,119.41 VRAM1.L12
FBA_CMD6: length 29.2
  BOTTOM w0.14: VRAM1.K4 161.65,124.99 161.65,123.7 161.18,123.24 153.89,123.24 152.12,125 152.12,132.48 149.22,135.38 147.05,135.38 146.41,134.73 146.41,134.62 146.06,134.27 145.82,134.27 145.29,133.74 GPU1.F25
FBA_CMD7: length 26.9
  BOTTOM w0.14: 145.24,134.31 145.45,134.51 145.96,134.51 146.17,134.72 146.17,134.83 147.3,135.97 149.42,135.97 152.68,132.71 152.68,125.32 154.41,123.6 160.74,123.6 161.2,124.06 VRAM1.K5
FBA_CMD8: length 30.8
  TOP w0.14: v1(160,125.03) 159.97,125 159.97,123.54 159.43,123 153.63,123 152.03,124.6 152.03,133.72 150.19,135.56 146.61,135.56 144.33,133.28 143.65,133.28 v1(143.54,133.18)
  BOTTOM w0.14: GPU1.F23 v1(143.54,133.18) ; VRAM1.J4 v1(160,125.03)
FBA_CMD9: length 30.9
  TOP w0.089: 143.94,132.99 143.54,132.58 v1(142.96,132.58)
  TOP w0.14: v1(160.4,124.07) 160.4,123.47 159.57,122.64 153.2,122.64 151.45,124.39 151.45,133.4 149.86,134.98 146.54,134.98 144.54,132.99 143.94,132.99
  BOTTOM w0.14: VRAM1.J5 160.4,124.07 v1(160.4,124.07) ; GPU1.G22 v1(142.96,132.58)
FBA_CMD10: length 30.4
  TOP w0.089: v1(142.96,133.76) 143.54,133.76 144,134.22
  TOP w0.14: 144,134.22 144.25,134.22 146.36,136.32 146.82,136.32 147.2,136.7 150.82,136.7 153.17,134.34 153.17,124.87 154.39,123.65 157.59,123.65 158.22,124.28 158.22,124.28 158.39,124.45 158.39,124.9 158.51,125.03 v1(159.2,125.03)
  BOTTOM w0.14: VRAM1.H4 v1(159.2,125.03) ; v1(142.96,133.76) 142.96,133.19 GPU1.G23
FBA_CMD11: length 28.4
  TOP w0.14: v1(144.1,133.74) 144.15,133.74 146.35,135.94 147.55,135.94 147.73,136.12 150.59,136.12 152.59,134.12 152.59,124.83 154.08,123.35 158.5,123.35 v1(159.29,124.14)
  BOTTOM w0.14: v1(144.1,133.74) GPU1.G24 ; VRAM1.H5 159.6,124.44 v1(159.29,124.14)
FBA_CMD12: length 24.3
  BOTTOM w0.14: GPU1.F27 147.46,136.53 149.65,136.53 153.27,132.91 153.27,131.47 153.77,130.96 154.23,130.96 154.36,130.82 154.36,130.42 154.5,130.28 154.78,130.28 154.92,130.42 154.92,130.82 155.06,130.96 155.34,130.96 155.48,130.82 155.48,130.42 155.62,130.28 155.9,130.28 156.04,130.42 156.04,130.82 156.18,130.96 156.46,130.96 156.6,130.82 156.6,130.44 156.74,130.3 157.02,130.3 157.16,130.44 157.16,130.82 157.3,130.96 157.64,130.96 158.45,130.14 158.45,128.67 159.17,127.96 159.17,126.6 VRAM1.G3
FBA_CMD13: length 25.1
  BOTTOM w0.14: 144.11,134.31 144.66,134.31 147.43,137.09 149.89,137.09 154.34,132.63 154.34,132.43 154.07,132.16 154.07,131.96 154.27,131.77 154.47,131.77 154.74,132.04 154.93,132.04 155.45,131.52 157.97,131.52 158.46,131.03 158.66,131.03 158.98,131.34 159.17,131.34 159.37,131.15 159.37,130.95 159.06,130.63 159.05,130.37 R7820.2 159.95,129.48 159.95,129.08 159.79,128.93 159.79,128.14 159.95,127.97 159.95,127.96 159.96,127.95 159.96,127.47 VRAM1.J2
FBA_CMD14: length 24
  BOTTOM w0.14: GPU1.G27 145.67,135.87 145.67,136.12 147.2,137.64 150.12,137.64 155.66,132.11 159.2,132.11 160.48,130.83 R7816.1 160.65,129.68 160.65,128.08 160.78,127.95 160.78,126.61 VRAM1.J3
FBA_CMD15: length 27.5
  BOTTOM w0.14: VRAM1.L3 161.55,126.68 161.55,128.71 162.06,129.21 162.06,130.99 160.35,132.69 155.86,132.69 150.31,138.24 147,138.24 145.21,136.45 145.21,135.94 144.68,135.41 GPU1.G26
FBA_CMD16: length 28.6
  TOP w0.089: 143.24,138.65 140.71,136.12 v1(140.6,136.12)
  TOP w0.14: v1(158.4,147.33) 158.4,145.9 157.66,145.16 154.23,145.16 153.24,146.15 151.83,146.15 148.92,143.25 148.73,143.25 148.35,143.63 148.15,143.63 147.95,143.43 147.95,143.23 148.33,142.85 148.33,142.65 148.12,142.44 147.11,142.44 146.97,142.58 146.97,143.09 146.83,143.23 146.55,143.23 146.41,143.09 146.41,142.58 146.27,142.44 145.62,142.44 143.24,140.07 143.24,138.65
  BOTTOM w0.14: GPU1.M24 140.6,136.68 v1(140.6,136.12) ; VRAM4.L12 v1(158.4,147.33)
FBA_CMD17: length 28.2
  TOP w0.089: v1(140.04,135.54) 140.61,135.53 142.19,137.12 143.06,137.12 143.8,137.86
  TOP w0.14: 143.8,137.86 143.8,139.84 143.97,140 144.16,140 144.31,139.86 144.51,139.86 144.71,140.06 144.71,140.25 144.56,140.4 144.56,140.6 144.76,140.79 144.95,140.79 145.1,140.65 145.3,140.65 145.5,140.85 145.5,141.04 145.35,141.19 145.35,141.39 145.85,141.89 148.9,141.89 149.18,142.17 149.18,142.71 152.06,145.59 153.22,145.59 153.56,145.25 153.93,144.88 158.83,144.88 159.19,145.24 v1(159.19,145.72)
  BOTTOM w0.14: v1(140.04,135.54) 140.04,136.11 GPU1.M23 ; VRAM4.K10 v1(159.19,145.72)
FBA_CMD18: length 29.5
  TOP w0.089: v1(141.8,136.07) 142.36,136.07 144.24,137.96
  TOP w0.14: v1(160,146.53) 160,146.53 160,144.96 159.59,144.55 153.92,144.55 153.46,145.01 152.27,145.01 149.74,142.48 149.74,140.9 149.43,140.59 149.16,140.59 149.02,140.73 149.02,141.14 148.88,141.28 148.6,141.28 148.46,141.14 148.46,140.73 148.32,140.59 148.04,140.59 147.9,140.73 147.9,141.14 147.77,141.28 147.49,141.28 147.35,141.14 147.35,140.73 147.21,140.59 146.93,140.59 146.79,140.73 146.79,141.14 146.65,141.28 146.37,141.28 146.23,141.14 146.23,140.78 144.24,138.79 144.24,137.96
  BOTTOM w0.14: VRAM4.K11 v1(160,146.53) ; GPU1.K24 141.79,136.06 v1(141.8,136.07)
FBA_CMD19: length 30.9
  TOP w0.089: 144.71,138.07 141.79,135.14 v1(141.79,134.94)
  TOP w0.14: v1(161.6,146.53) 161.6,146.04 161.49,145.92 161.49,145.21 161.74,144.96 162.56,144.96 162.69,144.83 162.69,144.32 162.56,144.2 153.65,144.2 153.42,144.43 152.48,144.43 150.35,142.29 150.35,140.23 150.14,140.03 146.27,140.03 144.71,138.48 144.71,138.07
  BOTTOM w0.14: v1(141.79,134.94) 141.23,134.94 GPU1.K23 ; VRAM4.H11 v1(161.6,146.53)
FBA_CMD20: length 27.1
  BOTTOM w0.14: GPU1.M27 142.3,139.91 143.37,140.99 143.37,142.21 143.75,142.58 143.75,142.78 143.57,142.96 143.57,143.16 143.76,143.36 143.96,143.36 144.14,143.17 144.34,143.17 145.06,143.89 145.52,143.89 145.66,144.03 145.66,144.24 145.8,144.37 146.08,144.37 146.22,144.24 146.22,144.03 146.36,143.89 146.64,143.89 146.78,144.03 146.78,144.24 146.92,144.37 147.2,144.37 147.34,144.24 147.34,144.03 147.48,143.89 148.11,143.89 149.13,142.88 151.18,142.88 153.01,144.71 160.58,144.71 161.06,145.19 161.06,145.99 VRAM4.H10
FBA_CMD21: length 29.1
  BOTTOM w0.14: VRAM4.G12 162.4,147.33 162.4,144.64 161.95,144.2 153.36,144.2 151.4,142.24 148.97,142.24 147.88,143.33 145.29,143.33 143.94,141.99 143.94,141.05 142.68,139.79 142.68,139.5 142.68,138.25 142.43,138 141.97,138 141.79,137.82 GPU1.M26
FBA_CMD22: length 28.7
  BOTTOM w0.14: GPU1.M25 141.76,137.25 142.23,137.72 142.54,137.72 142.94,138.12 142.94,138.24 142.94,139.12 142.94,139.26 144.5,140.82 144.5,141.71 145.14,142.34 145.55,142.34 145.69,142.48 145.69,142.62 145.82,142.75 146.12,142.75 146.25,142.62 146.25,142.48 146.39,142.34 146.67,142.34 146.81,142.48 146.81,142.62 146.94,142.75 147.24,142.75 147.37,142.62 147.37,142.48 147.51,142.34 148.03,142.34 148.71,141.67 151.64,141.67 151.91,141.4 152.2,141.4 152.5,141.71 152.5,142.32 153.9,143.71 161.04,143.71 161.65,143.1 161.65,141.78 VRAM4.H4
FBA_CMD23: length 27.1
  BOTTOM w0.14: GPU1.K26 142.92,137.15 143.35,137.58 143.53,137.58 143.84,137.89 143.84,139.35 145.06,140.57 145.06,140.95 145.19,141.07 145.66,141.07 145.79,141.2 145.79,141.62 145.93,141.76 146.21,141.76 146.35,141.62 146.35,141.18 146.49,141.04 146.77,141.04 146.91,141.18 146.91,141.62 147.05,141.76 147.33,141.76 147.46,141.62 147.46,141.18 147.6,141.04 151.48,141.04 152.33,140.18 152.81,140.18 153.06,140.44 153.06,141.95 154.4,143.29 160.63,143.29 161.2,142.72 VRAM4.H5
FBA_CMD24: length 31.2
  TOP w0.089: v1(141.23,134.37) 141.79,134.37 142.22,134.8 142.22,135.19 145.02,137.99
  TOP w0.14: v1(160.8,141.73) 160.78,141.75 160.78,143.05 160.93,143.21 162.18,143.21 162.31,143.33 162.31,143.77 162.21,143.87 152.71,143.87 150.9,142.06 150.9,139.73 150.65,139.47 146.5,139.47 145.02,137.99
  BOTTOM w0.14: VRAM4.J4 v1(160.8,141.73) ; v1(141.23,134.37) 140.66,134.37 GPU1.K22
FBA_CMD25: length 27.7
  TOP w0.089: 144.41,137.04 142.51,135.14 142.51,134.51 v1(142.36,134.37)
  TOP w0.14: 144.41,137.04 144.89,137.04 146.33,138.48 146.66,138.48 146.8,138.62 146.8,138.77 146.94,138.91 147.22,138.91 147.36,138.77 147.36,138.62 147.49,138.48 147.77,138.48 147.91,138.62 147.91,138.77 148.05,138.91 148.33,138.91 148.47,138.77 148.47,138.62 148.61,138.48 148.89,138.48 149.03,138.62 149.03,138.77 149.17,138.91 149.45,138.91 149.59,138.77 149.59,138.62 149.73,138.48 150.01,138.48 150.15,138.62 150.15,138.77 150.29,138.91 150.57,138.91 150.71,138.77 150.71,138.62 150.85,138.48 151.18,138.48 151.46,138.76 151.46,141.79 153.26,143.59 159.64,143.59 160.33,142.9 v1(160.33,142.67)
  BOTTOM w0.14: v1(142.36,134.37) GPU1.J23 ; v1(160.33,142.67) 160.33,142.2 VRAM4.J5
FBA_CMD26: length 27.1
  TOP w0.089: 144.5,136.68 143.5,135.68 v1(143.5,135.48)
  TOP w0.14: 144.5,136.68 145.41,136.68 146.6,137.87 147.06,137.87 147.06,137.87 151.27,137.87 151.86,137.27 152.37,137.27 152.49,137.4 152.49,138.22 152.35,138.36 152.16,138.36 152.02,138.5 152.02,138.77 152.16,138.91 152.35,138.91 152.49,139.05 152.49,139.33 152.35,139.47 152.16,139.47 152.02,139.61 152.02,139.89 152.16,140.03 152.35,140.03 152.49,140.17 152.49,140.45 152.35,140.59 152.16,140.59 152.02,140.73 152.02,141.01 152.16,141.15 152.35,141.15 152.49,141.29 152.49,142.03 153.77,143.31 159.08,143.31 159.97,142.42 159.97,141.76 v1(160,141.73)
  BOTTOM w0.14: 142.92,135.5 143.49,135.5 v1(143.5,135.48) ; VRAM4.K4 v1(160,141.73)
FBA_CMD27: length 26.7
  TOP w0.089: v1(142.95,134.93) 143.54,134.93 144.08,135.48 144.84,135.48 146.2,136.83
  TOP w0.14: v1(159.13,142.6) 158.75,142.98 154.25,142.98 153.05,141.78 153.05,137.33 153.75,136.63 153.75,136.07 153.27,135.59 152.76,135.59 151.04,137.31 146.83,137.31 146.36,136.83 146.2,136.83
  BOTTOM w0.14: GPU1.J24 142.36,134.93 v1(142.95,134.93) ; VRAM4.K5 v1(159.13,142.6)
FBA_CMD28: length 25.9
  BOTTOM w0.089: 159.14,138.16 159.14,138.56 159.2,138.62 159.2,140.13
  BOTTOM w0.14: 159.14,138.16 158.9,137.92 158.72,137.92 158.58,137.78 158.58,137.33 158.44,137.19 158.16,137.19 158.02,137.33 158.02,137.78 157.88,137.92 157.61,137.92 157.47,137.78 157.47,137.33 157.33,137.19 157.05,137.19 156.91,137.33 156.91,137.78 156.77,137.92 156.49,137.92 156.35,137.78 156.35,137.33 156.21,137.19 155.93,137.19 155.79,137.33 155.79,137.78 155.65,137.92 155.37,137.92 155.23,137.78 155.23,137.33 155.09,137.19 154.81,137.19 154.67,137.33 154.67,137.78 154.53,137.92 153.8,137.92 151.24,140.48 145.76,140.48 144.3,139.02 144.3,138 143.49,137.19 GPU1.K27 ; VRAM4.L3 159.2,140.13
FBA_CMD29: length 28.2
  BOTTOM w0.089: 160,137.98 160,138.23 160,139.33
  BOTTOM w0.14: 160,137.98 160.07,137.8 R7821.2 159.92,137.31 159.92,136.75 159.79,136.63 158.95,136.63 158.81,136.49 158.81,136.11 158.67,135.97 158.39,135.97 158.25,136.11 158.25,136.49 158.11,136.63 157.83,136.63 157.69,136.49 157.69,136.11 157.55,135.97 157.27,135.97 157.13,136.11 157.13,136.49 156.99,136.63 156.71,136.63 156.57,136.49 156.57,136.11 156.43,135.97 156.16,135.97 156.02,136.11 156.02,136.49 155.88,136.63 155.6,136.63 155.46,136.49 155.46,136.11 155.32,135.97 155.04,135.97 154.9,136.11 154.9,136.49 154.76,136.63 154.3,136.63 151.01,139.92 146.09,139.92 144.75,138.58 144.75,137.91 142.9,136.06 GPU1.K25 ; 160,139.33 VRAM4.J2
FBA_CMD30: length 27.9
  BOTTOM w0.089: 160.84,137.97 160.84,138.53 160.8,138.56 160.8,140.13
  BOTTOM w0.14: 160.84,137.97 160.84,137.26 160.48,136.91 R7824.1 160.48,135.61 160.28,135.41 159.32,135.41 159.18,135.27 159.18,134.99 159.04,134.85 158.76,134.85 158.62,134.99 158.62,135.27 158.48,135.41 158.2,135.41 158.06,135.27 158.06,134.99 157.92,134.85 157.64,134.85 157.5,134.99 157.5,135.27 157.36,135.41 157.08,135.41 156.94,135.27 156.94,134.99 156.8,134.85 156.53,134.85 156.39,134.99 156.39,135.27 156.25,135.41 155.97,135.41 155.83,135.27 155.83,134.99 155.69,134.85 155.41,134.85 155.27,134.99 155.27,135.27 155.13,135.41 154.72,135.41 150.77,139.36 146.35,139.36 145.24,138.25 145.24,137.82 GPU1.J27 ; VRAM4.J3 160.8,140.13
FBA_CMD31: length 27.7
  BOTTOM w0.089: 161.6,140.13 161.6,138.57 161.66,138.51 161.66,137.97
  BOTTOM w0.14: GPU1.J26 144.05,136.06 145.75,137.76 145.75,137.97 146.58,138.8 150.54,138.8 155.05,134.29 161.09,134.29 161.99,135.19 161.99,137.65 161.66,137.97 ; VRAM4.G3 161.6,140.13
FBA_D0: length 14.7
  L6 w0.089: v1(142.35,128.45) 142.96,128.45 143.14,128.27 143.15,128.27 144.22,127.2 144.41,127.2
  L6 w0.114: v1(153.62,125.81) 153.04,125.22 148.03,125.22 146.36,126.9 145.33,126.9 145.04,127.2 144.41,127.2
  BOTTOM w0.14: GPU1.E18 141.77,129.02 v1(142.35,128.45) ; VRAM1.A4 v1(153.62,125.81)
FBA_D1: length 14.7
  L6 w0.089: 144.78,128.96 144.26,129.47 143.57,129.47 143.28,129.19 142.04,129.19 141.63,129.6 v1(141.22,129.6)
  L6 w0.114: 144.78,128.96 144.78,128.88 146,127.66 147.21,127.66 147.37,127.51 153.52,127.51 v1(153.6,127.43)
  BOTTOM w0.14: VRAM1.A2 v1(153.6,127.43) ; v1(141.22,129.6) 140.65,129.6 GPU1.F18
FBA_D2: length 17.7
  L6 w0.089: 143.05,128.03 142.2,128.03 141.36,128.86 141.03,128.86 140.77,128.6 140.19,128.6 v1(140.02,128.43)
  L6 w0.114: 143.05,128.03 144.17,126.9 144.94,126.9 146.43,125.4 147.2,125.4 148.03,124.56 153.93,124.56 v1(154.38,125.01)
  BOTTOM w0.14: GPU1.E16 140.02,127.85 v1(140.02,128.43) ; VRAM1.B4 v1(154.38,125.01)
FBA_D3: length 17.6
  L6 w0.089: v1(140.63,130.18) 140.62,129.61 141.09,129.15 141.61,129.15 141.86,128.9 143.69,128.9 143.98,128.61 144.43,128.61 ; v1(154.4,126.63) 154,127.03 152.92,127.03
  L6 w0.114: 144.43,128.61 145.67,127.37 146.94,127.37 147.28,127.03 152.92,127.03
  BOTTOM w0.14: GPU1.F17 140.04,129.59 v1(140.63,130.18) ; v1(154.4,126.63) 154.8,127.03 VRAM1.B2
FBA_D4: length 17.4
  L6 w0.089: v1(156.8,125.83) 156.4,126.23 156.4,126.87 156.23,127.04 155.38,127.04 155.37,127.03 155.03,127.03 154.8,127.26 154.8,127.64 154.38,128.06 ; 147.39,128.47 147.05,128.8 146.07,128.8 145.07,129.81 145.07,129.81 144.84,130.04 144.83,130.04 144.82,130.05 143.1,130.05 v1(142.97,130.18)
  L6 w0.114: 154.38,128.06 153.97,128.47 147.39,128.47
  BOTTOM w0.14: GPU1.D20 142.95,130.16 v1(142.97,130.18) ; VRAM1.E4 v1(156.8,125.83)
FBA_D5: length 17
  L6 w0.089: v1(143.56,130.75) 144.05,130.75 144.49,131.19 144.83,131.19 145.36,130.65 145.36,130.07 146.21,129.22 147.32,129.22 147.44,129.1 148.03,129.1
  L6 w0.114: v1(156.79,127.44) 156.02,128.21 156.02,128.66 155.15,129.53 149.17,129.53 148.74,129.1 148.03,129.1
  BOTTOM w0.14: v1(143.56,130.75) 143.55,130.74 GPU1.D21 ; VRAM1.E2 v1(156.79,127.44)
FBA_D6: length 24.7
  L6 w0.089: 144.59,133.63 142.32,131.37 v1(141.79,131.37)
  L6 w0.114: 144.59,133.63 145.27,134.31 146.41,134.31 146.69,134.04 148.87,134.04 152.17,130.74 156.59,130.74 158.81,128.52 158.81,127.26 158.81,127.26 158.81,126.24 v1(158.39,125.82)
  BOTTOM w0.14: v1(141.79,131.37) GPU1.F20 ; VRAM1.F4 v1(158.39,125.82)
FBA_D7: length 23
  L6 w0.089: 157.44,129.12 157.61,128.96 157.61,128.05 158,127.66 VRAM1.F2 v1(157.59,126.62) ; v1(142.38,130.78) 142.56,130.97 143.14,130.97 143.37,131.2 143.37,131.24 144.52,132.39 144.52,133.14 144.78,133.4
  L6 w0.114: 144.78,133.4 145.42,134.04 146.31,134.04 146.56,133.78 148.37,133.78 151.9,130.25 156.31,130.25 157.44,129.12
  BOTTOM w0.14: VRAM1.F2 v1(157.59,126.62) ; GPU1.E21 142.97,130.78 v1(142.38,130.78)
FBA_D8: length 19.5
  L6 w0.089: 141.66,126 141.66,126.22 141.34,126.55 141.33,126.55 140.21,127.67 139.83,127.67 139.43,127.27 v1(138.86,127.27)
  L6 w0.114: v1(153.38,119.57) 153.01,119.94 150.88,119.94 149.36,121.46 146.92,121.46 142.83,125.55 142.12,125.55 141.66,126
  BOTTOM w0.14: VRAM1.A11 153.74,119.57 v1(153.38,119.57) ; GPU1.E15 139.47,127.27 v1(138.86,127.27)
FBA_D9: length 18.6
  L6 w0.089: v1(140.03,127.26) 140.49,126.79 140.49,126.2 141.07,125.62
  L6 w0.114: v1(153.33,118.76) 152.63,119.46 147.96,119.46 144.26,123.15 143.93,123.15 141.47,125.62 141.07,125.62
  BOTTOM w0.14: v1(153.33,118.76) 153.86,118.23 VRAM1.A13 ; GPU1.D15 140.04,127.25 v1(140.03,127.26)
FBA_D10: length 19.7
  L6 w0.089: 142.85,126.21 140.82,128.24 140.79,128.24 140.77,128.26 140.42,128.26 140.08,127.92 139.49,127.92 v1(139.44,127.86)
  L6 w0.114: 142.85,126.21 142.85,126.04 144.9,123.99 145.72,123.99 146.94,122.77 151.86,122.77 154.4,120.23 v1(154.4,120.23)
  BOTTOM w0.14: VRAM1.B11 154.4,120.23 v1(154.4,120.23) ; GPU1.F15 v1(139.44,127.86)
FBA_D11: length 21.1
  L6 w0.089: v1(138.29,126.7) 138.84,126.7 140.41,125.13 140.41,124.94 140.95,124.41
  L6 w0.114: 140.95,124.41 142.37,122.99 142.88,122.99 147.42,118.44 152.07,118.44 152.68,117.83 v1(154.4,117.83)
  BOTTOM w0.14: v1(154.4,117.83) 154.79,118.23 VRAM1.B13 ; GPU1.F13 137.71,126.7 v1(138.29,126.7)
FBA_D12: length 24.9
  L6 w0.089: v1(156.8,119.43) 156.4,119.03 156.4,116.55 156.34,116.49 ; 141.97,122.42 140.03,124.36 v1(139.43,124.36)
  L6 w0.114: 141.97,122.42 146.99,117.4 151.73,117.4 153.2,115.93 155.78,115.93 156.34,116.49
  BOTTOM w0.14: v1(139.43,124.36) 139.42,124.37 139.42,124.38 GPU1.C13 ; VRAM1.E11 v1(156.8,119.43)
FBA_D13: length 26.6
  L6 w0.089: v1(157.6,120.23) 157.2,119.84 157.2,118 157.21,118 157.21,116.26 157.19,116.24
  L6 w0.114: v1(140,123.8) 140,123.23 146.43,116.79 151.48,116.79 152.8,115.47 156.42,115.47 157.19,116.24
  BOTTOM w0.14: v1(157.6,120.23) 157.6,120.23 VRAM1.F11 ; GPU1.B13 139.98,124.38 139.98,123.81 v1(140,123.8)
FBA_D14: length 30
  L6 w0.089: 158.85,116.51 158.85,117.4 v1(158.42,117.83)
  L6 w0.114: v1(138.28,125.51) 138.43,125.36 138.43,124.46 139.2,123.7 139.2,122.48 145.9,115.77 151.06,115.77 152.48,114.35 156.76,114.35 158.85,116.45 158.85,116.51
  BOTTOM w0.14: VRAM1.F13 158,118.23 158.39,117.83 v1(158.42,117.83) ; v1(138.28,125.51) 138.28,126.07 GPU1.E13
FBA_D15: length 28.5
  L6 w0.089: 157.97,116.21 158.03,116.27 158.03,117.65 158.01,117.66 158.01,118.25 157.63,118.63 v1(157.62,118.63)
  L6 w0.114: v1(138.86,124.94) 138.86,124.34 139.58,123.63 139.58,122.75 146.04,116.28 151.27,116.28 152.74,114.81 156.57,114.81 157.97,116.21
  BOTTOM w0.14: v1(138.86,124.94) 138.86,125.5 GPU1.D13 ; v1(157.62,118.63) 157.59,118.63 157.2,118.24 VRAM1.E13
FBA_D16: length 36.6
  L3 w0.114: v1(167.24,119.39) 167.64,118.99 167.64,115.91 166.37,114.63 152.69,114.63 150.89,116.43 148.9,116.43 141.16,124.17 v1(141.16,124.87)
  BOTTOM w0.14: v1(141.16,124.87) 141.17,124.87 GPU1.B15 ; VRAM1.U11 v1(167.24,119.39)
FBA_D17: length 32.6
  L3 w0.114: v1(141.17,126.14) 142.11,125.19 142.11,124.94 149.71,117.35 151.29,117.35 153.09,115.55 165.39,115.55 166.35,116.5 166.35,117.78 v1(166.4,117.83)
  BOTTOM w0.14: VRAM1.T13 v1(166.4,117.83) ; v1(141.17,126.14) GPU1.C16
FBA_D18: length 38.9
  L3 w0.114: v1(141.09,122.73) 141.92,122.73 148.68,115.98 150.7,115.98 152.5,114.17 166.66,114.17 168.12,115.64 168.12,119.23 167.12,120.23 v1(166.4,120.23)
  BOTTOM w0.14: GPU1.A13 140.68,123.82 141.09,123.4 v1(141.09,122.73) ; VRAM1.T11 v1(166.4,120.23)
FBA_D19: length 32.8
  L3 w0.114: v1(167.2,117.83) 167.32,117.71 167.32,116.78 165.63,115.09 152.88,115.09 151.08,116.89 149.13,116.89 143.24,122.78 143.24,123.41 142.7,123.95 142.08,123.95 v1(142.07,123.95)
  BOTTOM w0.14: v1(142.07,123.95) 142.07,124.66 GPU1.A15 ; VRAM1.U13 v1(167.2,117.83)
FBA_D20: length 25.8
  L3 w0.114: v1(162.38,118.61) 162.38,119.25 161.8,119.84 161.8,121.48 161.52,121.76 152.47,121.76 151.24,122.99 146.3,122.99 145.66,123.62 145.27,123.62 142.95,125.94 142.95,126.71 v1(142.94,126.71)
  BOTTOM w0.14: v1(162.38,118.61) 162.42,118.61 VRAM1.M13 ; v1(142.94,126.71) 142.95,126.71 142.95,126.71 142.94,126.72 142.94,127.3 GPU1.B18
FBA_D21: length 26.4
  L3 w0.089: 162.83,120.8 162.81,120.78 162.81,119.58 162.78,119.55 162.78,118.29 v1(163.22,117.85)
  L3 w0.114: v1(143.49,126.09) 143.49,125.74 145.13,124.1 145.83,124.1 146.46,123.47 151.57,123.47 152.78,122.27 161.86,122.27 162.83,121.3 162.83,120.8
  BOTTOM w0.14: VRAM1.N13 v1(163.22,117.85) ; GPU1.A18 v1(143.49,126.09)
FBA_D22: length 25.2
  L3 w0.089: v1(164,119.43) 163.62,119.81 163.62,120.71 163.59,120.75
  L3 w0.114: v1(146.06,126.48) 146.06,125.85 147.53,124.39 151.95,124.39 153.25,123.09 162.07,123.09 163.59,121.57 163.59,120.75
  BOTTOM w0.14: v1(146.06,126.48) 145.21,127.32 GPU1.A19 ; VRAM1.N11 v1(164,119.43)
FBA_D23: length 25.8
  L3 w0.114: v1(144.52,125.33) 145.36,125.33 146.76,123.93 151.76,123.93 152.97,122.72 161.9,122.72 163.21,121.41 v1(163.21,120.24)
  BOTTOM w0.14: GPU1.C19 142.92,127.9 144.52,126.3 v1(144.52,125.33) ; v1(163.21,120.24) 163.2,120.23 163.2,120.23 VRAM1.M11
FBA_D24: length 27.9
  L3 w0.114: v1(167.21,125.02) 166.94,125.29 166.94,128.8 163.61,132.13 150.12,132.13 149.32,132.93 148.55,132.93 147,131.37 v1(147,130.84)
  BOTTOM w0.14: v1(147,130.84) 146.99,130.84 GPU1.B24 ; v1(167.21,125.02) 167.21,125.02 VRAM1.U4
FBA_D25: length 28.2
  L3 w0.114: v1(145.27,131.37) 146.43,131.37 148.39,133.32 149.43,133.32 150.12,132.64 163.75,132.64 167.79,128.61 167.79,127.45 v1(167.37,127.03)
  BOTTOM w0.14: 145.28,130.81 145.28,131.36 v1(145.27,131.37) ; VRAM1.U2 v1(167.37,127.03)
FBA_D26: length 24.7
  L3 w0.089: 166.01,126.86 166,126.86 166,126.23 v1(166.4,125.83)
  L3 w0.114: 166.01,126.86 166.41,127.27 166.41,128.68 163.5,131.6 150.44,131.6 149.02,130.18 148.27,130.18 v1(148.04,130.41)
  BOTTOM w0.14: VRAM1.T4 v1(166.4,125.83) ; v1(148.04,130.41) 148.01,130.41 GPU1.A25
FBA_D27: length 23.6
  L3 w0.114: v1(147.68,129.64) 147.98,129.95 149.58,129.95 150.77,131.14 163.31,131.14 165.48,128.97 165.48,128.3 166.01,127.77 166.01,127.2 165.6,126.79 v1(165.6,126.63)
  BOTTOM w0.14: VRAM1.T2 166,127.03 v1(165.6,126.63) ; GPU1.A24 147.04,130.28 v1(147.68,129.64)
FBA_D28: length 22.6
  L3 w0.089: v1(163.2,125.83) 163.57,126.2 163.57,127.79 163.2,128.16 163.2,129.05
  L3 w0.114: 163.2,129.05 162.99,129.26 151.22,129.26 150.62,128.65 146.75,128.65 146.61,128.8 146.09,128.8 146.09,128.8 v1(145.8,128.51)
  BOTTOM w0.14: v1(145.8,128.51) GPU1.A21 ; VRAM1.N4 v1(163.2,125.83)
FBA_D29: length 21.4
  L3 w0.089: v1(163.17,127.42) 163.17,127.43 162.4,128.2 162.4,128.58
  L3 w0.114: 162.4,128.58 162.18,128.8 151.65,128.8 150.92,128.07 149.61,128.07 149.28,128.4 148.55,128.4 v1(148.14,127.98)
  BOTTOM w0.14: v1(148.14,127.98) 148.09,127.94 147.55,127.94 145.14,127.94 144.68,128.41 GPU1.B21 ; v1(163.17,127.42) 163.21,127.42 VRAM1.N2
FBA_D30: length 21.7
  L3 w0.114: v1(144.1,129.06) 144.29,128.47 145.3,127.46 147.22,127.46 147.68,127 150.96,127 153.38,124.59 161.96,124.59 v1(162.4,125.02)
  BOTTOM w0.14: v1(144.1,129.06) 143.53,129.06 GPU1.C20 ; v1(162.4,125.02) 162.8,125.42 VRAM1.M4
FBA_D31: length 20.8
  L3 w0.114: v1(144.67,129.64) 144.67,129.03 145.94,127.76 147.35,127.76 147.58,127.54 151.28,127.54 151.66,127.92 161.11,127.92 v1(162.4,126.63)
  BOTTOM w0.14: v1(144.67,129.64) GPU1.C21 ; VRAM1.M2 v1(162.4,126.63)
FBA_D32: length 20.4
  L6 w0.089: 139.75,140 139.26,140 138.45,139.19 138.45,138.83 138.7,138.59 138.7,138.25 137.69,137.24 v1(137.69,136.7)
  L6 w0.114: v1(153.61,141.72) 153.42,141.53 143.64,141.53 142.34,140.23 139.98,140.23 139.75,140
  BOTTOM w0.14: v1(137.69,136.7) 137.69,137.27 GPU1.R22 ; VRAM4.U4 154,141.33 v1(153.61,141.72)
FBA_D33: length 16.6
  L6 w0.114: v1(138.85,139) 139.42,139 140.42,140.01 142.79,140.01 143.17,140.39 153.34,140.39 v1(153.6,140.13)
  BOTTOM w0.14: VRAM4.U2 v1(153.6,140.13) ; GPU1.R24 138.85,138.44 v1(138.85,139)
FBA_D34: length 21
  L6 w0.089: 139.51,140.33 139.44,140.27 139.26,140.27 139.01,140.03 138.13,140.03 137.87,139.77 137.87,139.42 138.08,139.2 138.08,138.82 137.7,138.43 v1(137.7,137.86)
  L6 w0.114: 139.51,140.33 139.74,140.56 141,140.56 142.58,142.14 153.99,142.14 v1(154.39,141.74)
  BOTTOM w0.14: GPU1.T22 137.69,137.84 v1(137.7,137.86) ; VRAM4.T4 v1(154.39,141.74)
FBA_D35: length 17.7
  L6 w0.089: 141.2,138.88 140.49,138.88 139.87,138.26 139.83,138.26 139.41,137.84 v1(138.86,137.84)
  L6 w0.114: 141.2,138.88 141.69,139.37 144.64,139.37 144.9,139.12 153.04,139.12 153.28,138.87 153.94,138.87 v1(154.4,139.33)
  BOTTOM w0.14: GPU1.R23 138.32,137.84 v1(138.86,137.84) ; VRAM4.T2 v1(154.4,139.33)
FBA_D36: length 21.2
  L6 w0.089: v1(141.19,137.82) 141.48,137.82 141.67,137.63 143.58,137.63 ; v1(157.6,140.93) 157.2,140.53 157.2,138.91 156.97,138.69 156.97,138.01
  L6 w0.114: 156.97,138.01 155.57,136.6 153.09,136.6 152.06,137.63 143.58,137.63
  BOTTOM w0.14: VRAM4.N4 v1(157.6,140.93) ; v1(141.19,137.82) 141.18,137.82 GPU1.N25
FBA_D37: length 18.8
  L6 w0.089: v1(156.8,140.13) 156.4,139.73 156.4,139.15 156,138.75 156,137.8
  L6 w0.114: 156,137.8 155.44,137.24 153.39,137.24 152.53,138.1 144.4,138.1 144.02,138.48 143.05,138.48 142.97,138.39 v1(141.75,138.39)
  BOTTOM w0.14: VRAM4.N2 v1(156.8,140.13) ; v1(141.75,138.39) 141.74,138.38 GPU1.N26
FBA_D38: length 24.9
  L6 w0.089: 142.89,137.33 141.1,137.33 140.76,137.67 140.37,137.67 139.93,137.23 v1(139.45,137.23) ; 157.32,138.44 158.02,139.14 158.02,141.35 v1(158.4,141.73)
  L6 w0.114: 157.32,138.44 157.32,137.67 155.79,136.14 152.76,136.14 151.73,137.17 144.94,137.17 144.78,137.33 142.89,137.33
  BOTTOM w0.14: v1(139.45,137.23) 139.45,137.23 139.47,137.21 GPU1.N23 ; VRAM4.M4 v1(158.4,141.73)
FBA_D39: length 21.9
  L6 w0.089: 143.03,136.7 142.62,137.11 141.04,137.11 140.91,137.24 v1(140.6,137.24) ; 158.31,137.95 158.31,139.22 v1(158.43,139.34)
  L6 w0.114: 158.31,137.95 156.04,135.69 152.53,135.69 151.51,136.7 143.03,136.7
  BOTTOM w0.14: GPU1.N24 140.04,137.24 v1(140.6,137.24) ; v1(158.43,139.34) 158.39,139.34 VRAM4.M2
FBA_D40: length 25.8
  L6 w0.089: 138.13,141.99 136.99,140.85 136.99,139.72 v1(137.1,139.61)
  L6 w0.114: v1(153.09,146.88) 153.05,146.93 149.66,146.93 147.54,144.81 147.08,144.81 146.97,144.69 146.97,144.51 146.85,144.4 146.63,144.4 146.51,144.51 146.51,144.69 146.4,144.81 146.17,144.81 146.05,144.69 146.05,144.51 145.94,144.4 145.71,144.4 145.6,144.51 145.6,144.69 145.48,144.81 145.25,144.81 145.14,144.69 145.14,144.51 145.03,144.4 144.8,144.4 144.68,144.51 144.68,144.69 144.57,144.81 144.34,144.81 144.23,144.69 144.23,144.51 144.11,144.4 143.88,144.4 143.77,144.51 143.77,144.69 143.65,144.81 143.43,144.81 143.31,144.69 143.31,144.51 143.2,144.4 142.97,144.4 142.85,144.51 142.85,144.69 142.74,144.81 142.51,144.81 142.4,144.69 142.4,144.51 142.28,144.4 142.05,144.4 141.94,144.51 141.94,144.69 141.82,144.81 141.6,144.81 141.48,144.69 141.48,144.51 141.37,144.4 141.14,144.4 141.02,144.51 141.02,144.69 140.91,144.81 140.06,144.81 138.13,142.88 138.13,141.99
  BOTTOM w0.14: VRAM4.U11 153.95,146.88 v1(153.09,146.88) ; v1(137.1,139.61) 136.55,139.61 GPU1.V23
FBA_D41: length 28.2
  L6 w0.089: v1(135.94,139.6) 135.94,140.18 136.35,140.59 136.35,140.95 136.04,141.26 136.04,141.43 136.35,141.74 136.35,142.27
  L6 w0.114: 136.35,142.27 140.57,146.48 140.6,146.48 140.76,146.64 141.35,146.64 141.46,146.75 141.46,147.31 141.57,147.42 141.8,147.42 141.92,147.31 141.92,146.75 142.03,146.64 142.26,146.64 142.37,146.75 142.37,147.31 142.49,147.42 142.72,147.42 142.83,147.31 142.83,146.75 142.95,146.64 143.17,146.64 143.29,146.75 143.29,147.31 143.4,147.42 143.63,147.42 143.75,147.31 143.75,146.75 143.86,146.64 146.46,146.64 148.84,149.02 v1(153.51,149.02)
  BOTTOM w0.14: GPU1.V22 135.94,139.04 v1(135.94,139.6) ; VRAM4.U13 v1(153.51,149.02)
FBA_D42: length 27.2
  L6 w0.089: v1(137.12,138.41) 137.12,139.03 137.53,139.44 137.53,139.76 137.24,140.05 137.24,140.7 138.62,142.08
  L6 w0.114: 138.62,142.08 138.62,143.01 138.92,143.31 139.55,143.31 139.68,143.18 140.36,143.18 141.13,143.94 147.32,143.94 149.85,146.47 150.71,146.47 150.83,146.35 150.83,145.76 150.94,145.64 151.17,145.64 151.28,145.76 151.28,146.35 151.4,146.47 151.63,146.47 151.74,146.35 151.74,145.76 151.86,145.64 152.08,145.64 152.2,145.76 152.2,146.35 152.31,146.47 152.72,146.47 153.24,145.95 153.82,145.95 v1(154.4,146.53)
  BOTTOM w0.14: GPU1.T23 137.14,138.44 v1(137.12,138.41) ; VRAM4.T11 v1(154.4,146.53)
FBA_D43: length 29.7
  L6 w0.089: v1(135.97,138.44) 135.97,139 135.2,139.77 135.2,139.84 135.01,140.03 135.01,140.42 135.54,140.95 135.54,140.95 135.78,141.19 135.78,141.19 135.79,141.2 135.79,141.52 135.47,141.84 135.47,142.06 135.84,142.43
  L6 w0.114: v1(154.4,148.93) 153.87,149.47 153.71,149.47 153.7,149.48 148.48,149.48 146.75,151.21 144.68,151.21 140.26,146.79 139.5,146.79 135.84,143.13 135.84,142.43
  BOTTOM w0.14: GPU1.U22 v1(135.97,138.44) ; VRAM4.T13 v1(154.4,148.93)
FBA_D44: length 33.4
  L6 w0.089: 156.8,150.48 156.8,148.97 v1(156.84,148.94)
  L6 w0.114: 156.8,150.48 156.35,150.93 148.34,150.93 147.15,152.12 144.29,152.12 139.97,147.8 138.51,147.8 135.21,144.5 134.42,144.5 134.32,144.41 133.73,143.82 133.73,142.32 134.7,141.35 v1(135.38,141.35)
  BOTTOM w0.14: v1(156.84,148.94) 157.2,148.57 VRAM4.N13 ; v1(135.38,141.35) GPU1.Y24
FBA_D45: length 31.6
  L6 w0.089: 155.79,150.47 155.92,150.34 155.92,149.62 156.42,149.12 156.42,147.71 v1(156.82,147.31) ; v1(134.79,141.94) 134.35,142.37 134.35,143.27 134.87,143.78
  L6 w0.114: 134.87,143.78 134.91,143.82 134.91,143.83 135.15,144.07 135.16,144.07 138.43,147.35 140.16,147.35 144.48,151.66 146.94,151.66 148.14,150.47 155.79,150.47
  BOTTOM w0.14: GPU1.AA24 135.33,141.94 v1(134.79,141.94) ; VRAM4.N11 v1(156.82,147.31)
FBA_D46: length 38.2
  L6 w0.114: v1(134.8,139.64) 133.81,140.63 132.95,142.26 132.95,144.6 135.09,146.74 135.32,147.21 137.26,149.15 140.01,149.15 143.89,153.04 147.55,153.04 148.74,151.85 156.72,151.85 158.49,150.08 158.49,149.44 v1(158.41,148.94)
  BOTTOM w0.14: VRAM4.M13 v1(158.41,148.94) ; GPU1.Y22 134.78,139.66 v1(134.8,139.64)
FBA_D47: length 38.3
  L6 w0.089: 157.26,150.67 157.65,150.27 157.65,149.5 158,149.15 158,148.74 158,148.74 158,147.5 VRAM4.M11 v1(157.6,146.53)
  L6 w0.114: v1(134.79,140.81) 133.16,142.43 133.16,144.43 133.97,145.24 134.59,145.24 137.51,148.16 138.94,148.16 139.04,148.27 139.79,148.27 144.1,152.58 147.35,152.58 148.54,151.39 156.54,151.39 157.26,150.67
  BOTTOM w0.14: v1(134.79,140.81) 134.78,140.82 GPU1.AA23 ; VRAM4.M11 v1(157.6,146.53)
FBA_D48: length 42
  L3 w0.114: v1(166.38,147.31) 167.66,148.59 167.66,150.22 166.51,151.37 162.25,151.37 161.18,152.44 151.37,152.44 150.7,153.11 143.74,153.11 141.15,150.52 138.79,150.52 136.81,148.54 v1(136.81,148.09)
  BOTTOM w0.14: v1(136.81,148.09) 136.21,148.09 135.27,147.15 GPU1.AD27 ; VRAM4.B11 v1(166.38,147.31)
FBA_D49: length 41.1
  L3 w0.114: v1(167.2,148.93) 166.77,149.36 166.77,150.47 166.2,151.04 162.18,151.04 161.32,151.89 151.23,151.89 150.5,152.63 143.94,152.63 141.35,150.04 138.96,150.04 138.03,149.11 138.03,148.1 v1(137.68,147.75)
  BOTTOM w0.14: v1(137.68,147.75) 137.68,146.42 136.83,145.57 136.83,145.19 136.03,144.4 136.03,144.09 136.33,143.8 136.33,143.51 135.89,143.08 GPU1.AB25 ; VRAM4.A13 v1(167.2,148.93)
FBA_D50: length 44
  L3 w0.114: v1(135.79,147.03) 135.92,147.16 135.92,148.41 138.56,151.06 141,151.06 143.54,153.6 150.9,153.6 151.6,152.9 161.37,152.9 162.44,151.82 166.7,151.82 168.02,150.51 168.02,148.15 v1(167.2,147.33)
  BOTTOM w0.14: v1(135.79,147.03) 135.68,146.92 135.68,145.26 135.36,144.95 134.81,144.95 GPU1.AD26 ; VRAM4.A11 v1(167.2,147.33)
FBA_D51: length 38.9
  L3 w0.114: v1(138.54,148.61) 138.54,148.82 139.28,149.56 141.56,149.56 144.16,152.16 150.22,152.16 150.94,151.44 161.17,151.44 161.88,150.72 165.51,150.72 165.91,150.33 165.91,149.42 v1(166.4,148.93)
  BOTTOM w0.14: v1(138.54,148.61) 138.14,148.21 137.54,148.21 137.07,147.75 137.06,147.75 136.81,147.5 136.81,147.49 136.2,146.87 136.2,146.2 136.02,146.02 136.02,145.27 135.44,144.69 135.24,144.69 134.74,144.19 GPU1.AC25 ; VRAM4.B13 v1(166.4,148.93)
FBA_D52: length 31.8
  L3 w0.089: 162.03,146.76 161.98,146.81 161.98,147.93 162.4,148.35 v1(162.4,148.93)
  L3 w0.114: v1(138.6,146.66) 138.62,146.69 142.6,146.69 151.97,146.69 153.65,145 159.31,145 160.32,146.01 161.75,146.01 162.03,146.29 162.03,146.76
  BOTTOM w0.14: VRAM4.F13 v1(162.4,148.93) ; 137.04,143.64 137.22,143.82 137.22,144.5 138.66,145.94 v1(138.6,146.66)
FBA_D53: length 32.9
  L3 w0.089: v1(163.2,148.13) 162.82,147.75 162.82,147.02 162.74,146.94 162.74,146.89
  L3 w0.114: 162.74,146.89 162.36,146.51 162.36,145.14 161.77,144.55 153.46,144.55 151.78,146.22 138.83,146.22 138,145.4 v1(137.35,145.4)
  BOTTOM w0.14: VRAM4.E13 v1(163.2,148.13) ; GPU1.AA26 136.6,143.2 136.6,143.77 136.92,144.09 136.92,144.76 137.35,145.19 v1(137.35,145.4)
FBA_D54: length 36.2
  L3 w0.114: v1(163.2,146.53) 163.35,146.38 163.35,145.11 162.33,144.09 151.91,144.09 151.8,144.2 151.8,145.1 151.69,145.21 151.46,145.21 151.34,145.1 151.34,144.2 151.23,144.09 151,144.09 150.89,144.2 150.89,145.1 150.77,145.21 150.54,145.21 150.43,145.1 150.43,144.2 150.31,144.09 149.86,144.09 149.51,143.74 148.23,143.74 146.2,145.77 139.16,145.77 v1(138.94,145.55)
  BOTTOM w0.14: v1(138.94,145.55) 138.94,144.48 137.49,143.04 137.49,142.06 137.66,141.89 ; VRAM4.F11 v1(163.2,146.53)
