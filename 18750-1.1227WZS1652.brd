# Allegro board 18750-1.1227WZS1652.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
SOD882-10D6-1H20
  rect 0.61x0.457 smd: 1(0,0.457) 2(0,-0.457)
SOD882-10D6-UH22
  rect 0.61x0.457 smd: 1(0,0.457) 2(0,-0.457)
SOD-523-2H26
  rect 0.559x0.762 smd: 1(0,0.724) 2(0,-0.724)
SOIC8-1H86
  rect 0.635x1.524 smd: 1(-1.905,-3.442) 2(-0.635,-3.442) 3(0.635,-3.442) 4(1.905,-3.442) 5(1.905,3.442) 6(0.635,3.442) 7(-0.635,3.442) 8(-1.905,3.442)
SOIC8-G3530H63
  rect 0.635x1.524 smd: 1(-1.905,-2.492) 2(-0.635,-2.492) 3(0.635,-2.492) 4(1.905,-2.492) 5(1.905,2.492) 6(0.635,2.492) 7(-0.635,2.492) 8(-1.905,2.492)
  rect 3.505x2.997 smd: 9(0,0)
SOT23-2D4-312H44
  custom 0.171x0.171 smd: 1(-0.95,-1.069) 2(0.95,-1.069) 3(0,1.069)
SOT23-2D4-312H46
  custom 0.171x0.171 smd: 1(-0.95,-1.069) 2(0.95,-1.069) 3(0,1.069)
SOT23-2D8-312H58
  custom 0.171x0.171 smd: 1(-0.95,-1.21) 2(0.95,-1.21) 3(0,1.21)
SOT23CBE2D4H44
  custom 0.165x0.165 smd: B(-0.95,-1.073) C(0,1.073) E(0.95,-1.073)
SOT23CBE2D4H46-U
  custom 0.165x0.165 smd: B(-0.95,-1.073) C(0,1.073) E(0.95,-1.073)
SOT23CBE2D6H62
  custom 0.165x0.165 smd: B(-0.95,-1.016) C(0,1.016) E(0.95,-1.016)
SOT23DGS2D4H44
  custom 0.171x0.171 smd: D(0,1.069) G(-0.95,-1.069) S(0.95,-1.069)
SOT23DGS2D4H48
  custom 0.171x0.171 smd: D(0,1.069) G(-0.95,-1.069) S(0.95,-1.069)
SOT323CBE2D2H40
  custom 0.152x0.152 smd: B(-0.65,-0.864) C(0,0.864) E(0.65,-0.864)
SOT-6H58
  rect 0.61x0.813 smd: 1(-0.95,-1.219) 2(0,-1.219) 3(0.95,-1.219) 4(0.95,1.219) 5(0,1.219) 6(-0.95,1.219)
SOT-23-5H52
  rect 0.686x0.864 smd: 1(-0.953,-1.232) 2(0,-1.232) 3(0.953,-1.232) 4(0.953,1.232) 5(-0.953,1.232)
SOT-23-5H56
  rect 0.686x0.864 smd: 1(-0.953,-1.232) 2(0,-1.232) 3(0.953,-1.232) 4(0.953,1.232) 5(-0.953,1.232)
SOT-23-5H58
  rect 0.686x0.864 smd: 1(-0.953,-1.232) 2(0,-1.232) 3(0.953,-1.232) 4(0.953,1.232) 5(-0.953,1.232)
SOT-23-9H44
  custom 0.165x0.165 smd: 1(-0.953,-1.056) 2(0.953,-1.056) 3(0,1.056)
SOT-323H44
  custom 0.152x0.152 smd: 1(-0.65,-1.011) 2(0.65,-1.011) 3(0,1.011)
SOT-363H44
  rect 0.356x0.965 smd: 1(-0.65,-0.826) 2(0,-0.826) 3(0.65,-0.826) 4(0.65,0.826) 5(0,0.826) 6(-0.65,0.826)
SPR5630H142
  rect 5.283x2.692 smd: 1(-2.413,0)
STF237R113H86
  round 6.02 hole 2.87: 1(0,0)
TPAD14-OP
  round 0.356 smd: 1(0,0)
TPAD28
  round 0.711 smd: 1(0,0)
TQFP128-2H48
  rect 0.203x1.27 smd: 1(6.2,7.62) 2(5.8,7.62) 3(5.4,7.62) 4(5,7.62) 5(4.6,7.62) 6(4.2,7.62) 7(3.8,7.62) 8(3.4,7.62) 9(3,7.62) 10(2.6,7.62) 11(2.2,7.62) 12(1.8,7.62) 13(1.4,7.62) 14(0.999,7.62) 15(0.599,7.62) 16(0.199,7.62) 17(-0.199,7.62) 18(-0.599,7.62) 19(-0.999,7.62) 20(-1.4,7.62) 21(-1.8,7.62) 22(-2.2,7.62) 23(-2.6,7.62) 24(-3,7.62) 25(-3.4,7.62) 26(-3.8,7.62) 27(-4.2,7.62) 28(-4.6,7.62) 29(-5,7.62) 30(-5.4,7.62) 31(-5.8,7.62) 32(-6.2,7.62) 65(-6.2,-7.62) 66(-5.8,-7.62) 67(-5.4,-7.62) 68(-5,-7.62) 69(-4.6,-7.62) 70(-4.2,-7.62) 71(-3.8,-7.62) 72(-3.4,-7.62) 73(-3,-7.62) 74(-2.6,-7.62) 75(-2.2,-7.62) 76(-1.8,-7.62) 77(-1.4,-7.62) 78(-0.999,-7.62) 79(-0.599,-7.62) 80(-0.199,-7.62) 81(0.199,-7.62) 82(0.599,-7.62) 83(0.999,-7.62) 84(1.4,-7.62) 85(1.8,-7.62) 86(2.2,-7.62) 87(2.6,-7.62) 88(3,-7.62) 89(3.4,-7.62) 90(3.8,-7.62) 91(4.2,-7.62) 92(4.6,-7.62) 93(5,-7.62) 94(5.4,-7.62) 95(5.8,-7.62) 96(6.2,-7.62)
  rect 1.27x0.203 smd: 33(-7.62,6.2) 34(-7.62,5.8) 35(-7.62,5.4) 36(-7.62,5) 37(-7.62,4.6) 38(-7.62,4.2) 39(-7.62,3.8) 40(-7.62,3.4) 41(-7.62,3) 42(-7.62,2.6) 43(-7.62,2.2) 44(-7.62,1.8) 45(-7.62,1.4) 46(-7.62,0.999) 47(-7.62,0.599) 48(-7.62,0.199) 49(-7.62,-0.199) 50(-7.62,-0.599) 51(-7.62,-0.999) 52(-7.62,-1.4) 53(-7.62,-1.8) 54(-7.62,-2.2) 55(-7.62,-2.6) 56(-7.62,-3) 57(-7.62,-3.4) 58(-7.62,-3.8) 59(-7.62,-4.2) 60(-7.62,-4.6) 61(-7.62,-5) 62(-7.62,-5.4) 63(-7.62,-5.8) 64(-7.62,-6.2) 97(7.62,-6.2) 98(7.62,-5.8) 99(7.62,-5.4) 100(7.62,-5) 101(7.62,-4.6) 102(7.62,-4.2) 103(7.62,-3.8) 104(7.62,-3.4) 105(7.62,-3) 106(7.62,-2.6) 107(7.62,-2.2) 108(7.62,-1.8) 109(7.62,-1.4) 110(7.62,-0.999) 111(7.62,-0.599) 112(7.62,-0.199) 113(7.62,0.199) 114(7.62,0.599) 115(7.62,0.999) 116(7.62,1.4) 117(7.62,1.8) 118(7.62,2.2) 119(7.62,2.6) 120(7.62,3) 121(7.62,3.4) 122(7.62,3.8) 123(7.62,4.2) 124(7.62,4.6) 125(7.62,5) 126(7.62,5.4) 127(7.62,5.8) 128(7.62,6.2)
unnamed#2
  round 1.016 smd: (0,0)
XFORM12A127096H81
  rect 0.762x1.6 smd: 1(-4.445,-4.255) 2(-3.175,-4.255) 3(-1.905,-4.255) 4(1.905,-4.255) 5(3.175,-4.255) 6(4.445,-4.255) 7(4.445,4.255) 8(3.175,4.255) 9(1.905,4.255) 10(-1.905,4.255) 11(-3.175,4.255) 12(-4.445,4.255)

## Nets
1V_CPU_CORE: CPU1.AN9 CPU1.AN10 CPU1.AN24 CPU1.AN26 CPU1.AN27 CPU1.AP2 CPU1.AP9 CPU1.AP24 CPU1.AP26 CPU1.AR5 CPU1.AR6 CPU1.AR7 CPU1.AR8 CPU1.AR10 CPU1.AR25 CPU1.AR27 CPU1.AT9 CPU1.AT24 CPU1.AT26 CPU1.AU5 CPU1.AU6 CPU1.AU7 CPU1.AU8 CPU1.AU9 CPU1.AU24 CPU1.AU25 CPU1.AU26 CPU1.AU27 CPU1.AV2 CPU1.AV5 CPU1.AV7 CPU1.AV10 CPU1.AV27 CPU1.AW5 CPU1.AW6 CPU1.AW7 CPU1.AW8 CPU1.AW9 CPU1.AW10 CPU1.AW24 CPU1.AW25 CPU1.AW26 CPU1.AW27 CPU1.AY24 CPU1.AY26 CPU1.BA5 CPU1.BA7 CPU1.BA8 CPU1.BA25 CPU1.BA27 CPU1.BB2 CPU1.BB26 CPU1.BC5 CPU1.BC6 CPU1.BC7 CPU1.BC9 CPU1.BC10 CPU1.BC26 CPU1.BC27 CPU1.BD5 CPU1.BD8 CPU1.BD10 CPU1.BD25 CPU1.BD27 CPU1.BE9 CPU1.BE24 CPU1.BE25 CPU1.BE26 CPU1.BE27 CPU1.BF2 CPU1.BF9 CPU1.BF24 CPU1.BF26 CPU1.BG27 PC1002.1 PC1003.1 PC1004.1 PC1005.1 PC1006.1 PC1007.1 PC1008.1 PC1009.1 PC1010.1 PC1011.1 PC1012.1 PC1013.1 PC1014.1 PC1015.1 PC1016.1 PC1017.1 PC1018.1 PC1019.1 PC1020.1 PC1021.1 PC1022.1 PC1023.1 PC1024.1 PC1025.1 PC1026.1 PC1027.1 PC1028.1 PC1029.1 PC1030.1 PC1031.1 PC1032.1 PC1034.1 PC1036.1 PC1079.1 PC1080.1 PC1081.1 PC1082.1 PC1083.1 PC1084.1 PG4809.2 PG4815.2 PL4801.2 PL4802.2 PR4631.2 PT4801.1 PT4803.1 R707.1 R811.1 R815.1 R816.1
1V_GT_CORE: CPU1.AA9 CPU1.AB2 CPU1.AB8 CPU1.AB9 CPU1.AB10 CPU1.AC8 CPU1.AD9 CPU1.AE8 CPU1.AE9 CPU1.AE10 CPU1.AF2 CPU1.AF8 CPU1.AF10 CPU1.AG8 CPU1.AG9 CPU1.AH9 CPU1.AJ8 CPU1.AJ10 CPU1.AK2 CPU1.AK9 CPU1.AL8 CPU1.AL9 CPU1.AL10 CPU1.AM8 CPU1.V2 CPU1.Y8 CPU1.Y10 R811.2 R812.1 R815.2 R816.2 R817.1
1V_VCCGT: C1102.1 C1103.1 C1104.1 C1105.1 C1106.1 C1107.1 CPU1.A5 CPU1.A6 CPU1.A8 CPU1.A11 CPU1.A12 CPU1.A14 CPU1.A15 CPU1.A17 CPU1.A18 CPU1.A20 CPU1.B3 CPU1.B4 CPU1.B6 CPU1.B8 CPU1.B11 CPU1.B14 CPU1.B17 CPU1.B20 CPU1.C2 CPU1.C3 CPU1.C6 CPU1.C7 CPU1.C8 CPU1.C11 CPU1.C12 CPU1.C14 CPU1.C15 CPU1.C17 CPU1.C18 CPU1.C20 CPU1.D4 CPU1.D7 CPU1.D11 CPU1.D12 CPU1.D14 CPU1.D15 CPU1.D17 CPU1.D18 CPU1.D20 CPU1.E4 CPU1.F5 CPU1.F6 CPU1.F7 CPU1.F8 CPU1.F11 CPU1.F14 CPU1.F17 CPU1.F20 CPU1.G11 CPU1.G12 CPU1.G14 CPU1.G15 CPU1.G17 CPU1.G18 CPU1.G20 CPU1.H5 CPU1.H6 CPU1.H7 CPU1.H8 CPU1.H11 CPU1.H12 CPU1.H14 CPU1.H15 CPU1.H17 CPU1.H18 CPU1.H20 CPU1.J7 CPU1.J8 CPU1.J11 CPU1.J14 CPU1.J17 CPU1.J20 CPU1.K2 CPU1.K11 CPU1.L7 CPU1.L8 CPU1.L10 CPU1.M9 CPU1.N7 CPU1.N8 CPU1.N9 CPU1.N10 CPU1.P2 CPU1.P8 CPU1.R9 CPU1.T8 CPU1.T9 CPU1.T10 CPU1.U8 CPU1.U10 CPU1.V9 CPU1.W8 CPU1.W9 EC4701.1 FC8904.1 FC8905.1 FC8906.1 FC8990.1 FC8991.1 PC1001.1 PC1037.1 PC1038.1 PC1039.1 PC1040.1 PC1041.1 PC1042.1 PC1043.1 PC1044.1 PC1045.1 PC1046.1 PC1047.1 PC1048.1 PC1049.1 PC1050.1 PC1051.1 PC1052.1 PC1053.1 PC1054.1 PC1055.1 PC1056.1 PC1057.1 PC1058.1 PC1059.1 PC1060.1 PC1061.1 PC1062.1 PC1063.1 PC1064.1 PC1065.1 PC1066.1 PC1067.1 PC1068.1 PC1069.1 PC1070.1 PG4708.2 PL4701.2 PR4663.1 PT4701.1 R807.1 R812.2 R817.2
1V_VCCIO: C1108.1 C1109.1 C1110.1 C1111.1 C1133.1 C1134.1 C1135.1 C4007.1 CPU1.AK24 CPU1.AK26 CPU1.AL24 CPU1.AL25 CPU1.AL26 CPU1.AL27 CPU1.AM25 CPU1.AM27 CPU1.BH24 CPU1.BH25 CPU1.BH26 CPU1.BH27 CPU1.BJ24 CPU1.BJ26 CPU1.BP16 CPU1.BP18 FC8992.1 R401.1 R4038.1 U4002.6 U4002.7 U4002.8
1V_VCCSA: CPU1.BG8 CPU1.BG10 CPU1.BH9 CPU1.BJ8 CPU1.BJ9 CPU1.BJ10 CPU1.BK8 CPU1.BK25 CPU1.BK27 CPU1.BL8 CPU1.BL9 CPU1.BL10 CPU1.BL24 CPU1.BL26 CPU1.BM24 CPU1.BN25 EC5001.1 FC8993.1 PC1071.1 PC1072.1 PC1073.1 PC1074.1 PC1075.1 PC1076.1 PC1077.1 PC1078.1 PG5001.2 PL5001.2 R810.1
1V_VCCST_CPU: C801.1 C805.2 C806.2 C807.1 CPU1.BP2 CPU1.BP11 CPU1.BR11 CPU1.BT11 PC4602.1 PR4603.1 PR4604.1 PR4605.1 PR4606.1 R308.1 R704.1 R705.1 R706.1 R4036.2
1V_VCCST_CPU_R: C4012.1 R4036.1 U4006.6 U4006.7 U4006.8
1V_VCCSTG: C802.1 CPU1.BG1 CPU1.BG2 CPU1.BG3 FC8981.1 R301.1 R309.2 R310.2 R311.2 R312.2 R313.2 R314.2 R315.2 R4038.2
1V_VGA_CORE: C7744.1 C7745.1 C7746.1 C8001.1 C8002.1 C8008.1 C8009.1 C8010.1 C8011.1 C8012.1 C8013.1 C8014.1 C8015.1 C8016.1 C8017.1 C8018.1 C8019.1 C8020.1 C8021.1 C8022.1 C8023.1 C8024.1 C8025.1 C8026.1 C8030.1 C8031.1 C8032.1 C8038.1 C8039.1 C8040.1 C8041.1 C8042.1 C8043.1 EC8961.1 EC8965.1 EC8966.1 EC8967.1 EC8968.1 FC8987.1 FC8988.1 GPU1.G1 GPU1.G2 GPU1.G3 GPU1.G4 GPU1.G5 GPU1.G6 GPU1.G7 GPU1.H3 GPU1.H4 GPU1.H6 GPU1.J1 GPU1.J2 GPU1.J3 GPU1.J4 GPU1.J5 GPU1.J6 GPU1.J7 GPU1.K1 GPU1.K2 GPU1.K3 GPU1.K4 GPU1.K5 GPU1.K6 GPU1.K7 GPU1.K10 GPU1.K12 GPU1.K14 GPU1.K16 GPU1.K18 GPU1.L3 GPU1.L4 GPU1.L11 GPU1.L13 GPU1.L15 GPU1.L17 GPU1.M1 GPU1.M2 GPU1.M3 GPU1.M4 GPU1.M5 GPU1.M7 GPU1.M10 GPU1.M12 GPU1.M14 GPU1.M16 GPU1.M18 GPU1.N1 GPU1.N2 GPU1.N3 GPU1.N4 GPU1.N5 GPU1.N7 GPU1.N11 GPU1.N13 GPU1.N15 GPU1.N17 GPU1.P3 GPU1.P4 GPU1.P6 GPU1.P10 GPU1.P12 GPU1.P14 GPU1.P16 GPU1.P18 GPU1.R1 GPU1.R2 GPU1.R3 GPU1.R4 GPU1.R5 GPU1.R6 GPU1.R7 GPU1.R11 GPU1.R13 GPU1.R15 GPU1.R17 GPU1.T1 GPU1.T2 GPU1.T3 GPU1.T4 GPU1.T5 GPU1.T6 GPU1.T7 GPU1.T10 GPU1.T12 GPU1.T14 GPU1.T16 GPU1.T18 GPU1.U3 GPU1.U4 GPU1.U6 GPU1.U11 GPU1.U13 GPU1.U15 GPU1.U17 GPU1.V1 GPU1.V2 GPU1.V3 GPU1.V4 GPU1.V10 GPU1.V12 GPU1.V14 GPU1.V16 GPU1.V18 GPU1.W1 GPU1.W2 GPU1.W3 GPU1.W4 PL8508.2 PL8509.2 PR8504.1 PT8508.1 PT8511.1 PT8512.1 R8001.1 R8002.1 R8706.1
1V_VGA_S0: C7610.1 C7611.1 C7612.1 C7613.1 C7623.1 C7625.1 C7626.1 GPU1.AA22 GPU1.AB23 GPU1.AC24 GPU1.AD25 GPU1.AE26 GPU1.AE27 L7602.2 PG8608.2 PG8622.2 R8606.2 R8702.1
1V_VGA_S0_EN: PU8603.7 Q8703.2 U8801.4
1V_VGA_S0_PG: PU8603.2 R8806.2 U8803.1
3V5V_CT1: C4001.1 U4001.12
3V5V_CT2: C4002.1 U4004.12
3V_5V_DSW_OK: D2503.3 PR5308.2 R2514.2 U2502.4
3V_5V_EN: C4009.1 D4001.A PR4504.1 PR4516.1 R4006.1 R4009.1 R4014.1
3V_5V_POK: D2503.1 ED1703.2 PR4505.2 PU4501.9 PU4501.10 PU4502.9 PU4502.10 Q1701.2 R4033.1
3V_5V_POK#: Q1701.5 Q1701.6 R1726.1
5V_3V_TPAN_PWR: C5520.1 R5557.2 R5558.2 U5503.6 U5503.7
5V_AUX_S5: PG4528.2
5V_FAN_VCC: AFTP2603.1 C2603.1 C2604.1 C2605.1 D2601.K FAN1.1 R2612.2
5V_HDD_S0: C6007.1 C6008.1 FC9002.1 HDD1.8 HDD1.10 HDD1.11 HDD1.12 HDD2.9 HDD2.10 HDD2.11 R6001.2
5V_HDMI: C5736.2 F5701.2 HDMI1.18 U5702.2
5V_IRLED: AFTP5512.1 C5504.1 F5506.2 LCD1.24
5V_ODD_S0: AFTP6006.1 C6018.1 C6019.1 FC9003.1 FC9004.1 ODD1.12 ODD1.13 ODD1.14 ODD1.15 R6003.2
5V_S0: C4005.1 D5701.3 EC6601.1 EC8933.1 EC8934.1 EC8935.1 EC8936.1 EC8937.1 EC8938.1 EC8939.1 ED5502.5 ED6601.5 F5506.1 F5701.1 F6501.1 FC8902.1 FC8903.1 FC8912.1 FC8913.1 FC8914.1 FC8915.1 FC8916.1 PR8551.1 Q5701.G Q6505.E R2612.1 R2701.1 R2703.2 R2736.1 R5502.1 R6001.1 R6003.1 R7014.1 U4004.13 U4004.14 U5702.3 VGABD1.1
5V_S5: AFTP4501.1 AFTP4502.1 C3507.1 C3602.1 C4031.1 C4032.1 C4041.1 C7205.1 C7206.1 C7403.1 C7404.1 EC8947.1 EC8948.1 EC8949.1 EC8986.1 EC8987.1 EC8988.1 EC8989.1 EC8990.1 FC8917.1 FC8961.1 IOBD1.17 IOBD1.18 IOBD1.19 IOBD1.20 PC4514.1 PC4515.1 PC4516.1 PC4517.1 PC4518.1 PC4527.1 PC4529.1 PC4766.1 PC4866.1 PC4877.1 PC5001.1 PC5120.1 PC5121.1 PC5202.1 PG4527.2 PL4502.2 PR4610.1 PR4670.2 PR4704.2 PR4803.2 PR4813.2 PR5108.1 PU4701.29 PU4801.29 PU4802.29 PU5001.6 PU5101.6 PU5201.21 Q6403.E Q6404.E Q6405.E R3602.1 R3605.1 R3606.1 R4303.1 R5558.1 R7205.1 U3502.5 U3601.1 U4001.4 U4002.3 U4003.3 U4004.1 U4004.2 U4004.4 U4006.3 U5503.4 U7202.2 U7403.A1 U7403.A2 U8601.4
5V_TPAN_PWR: F5505.1 R5502.2 U5503.8 U5503.9
5V_TPAN_VDD: AFTP5513.1 C5516.1 C5517.1 F5505.2 FC8918.1 LCD1.25
5V_USB30_VCCA: AFTP3508.1 C3516.1 C3517.1 C3518.1 C3519.1 FC8909.1 R3618.1 U3502.1 USB2.1
5V_VCONN_EN: R7205.2 U7202.3
5V_VCONN_P1: R7203.1 U7202.5 U7202.6
5V_VCONN_P1_CCG4: R7203.2 U7201.5
19V_AD+: C4303.1 C4304.1 C4305.1 C4306.1 PD4401.1 PD4408.1 PR4464.2 PR4465.1 PR4473.1 PU4301.5 PU4301.6 PU4301.7 PU4301.8 PU4302.5 PU4302.6 PU4302.7 PU4302.8 R4311.1 R4316.1
20V_DCBATOUT: AFTP4408.1 PC4402.1 PC4403.1 PC4404.1 PC4405.1 PG4402.1 PG4419.1 PR4401.2 PR4439.1 PU4403.5 PU4403.6 PU4403.7 PU4403.8
20V_VCCPD_VBUS: AFTP7301.1 AFTP7302.1 C7214.1 C7302.1 C7303.1 C7304.1 C7305.1 C7306.1 C7307.1 D7401.K JUSB1.A4 JUSB1.A9 JUSB1.B4 JUSB1.B9 R7201.2 R7217.1 R7410.1 R7423.1 R7425.1 R7426.1 U7203.6 U7403.C2 U7403.D1 U7403.D2 U7419.B2 U7419.C2 U7419.D2 U7419.E1 U7419.E2
20V_VCCPD_VBUS_R: C7201.2 R7201.1 R7213.2 U7201.3
+1.8VALW_EC: C2423.1 R2462.1 U2401.54
+3V_1D8V_DVDD: C2720.1 C2721.1 C2723.1 C2736.1 C2740.1 C2741.1 HDA27.1 HDA27.8 R2710.1 R2715.2 R2717.1
+3VALW_EC: C2410.1 C2411.1 C2412.1 C2413.1 C2414.1 C2420.1 C2422.1 C2429.1 DBEC1.1 ED4304.2 ED4305.2 ED4306.2 Q2417.2 Q2417.5 R2414.2 R2415.2 R2424.2 R2443.1 R2446.2 R2450.2 R2480.2 R2608.1 R7215.1 RN2402.1(A) RN2402.2(A) RN2403.1(A) RN2403.2(A) RN2403.3(A) RN2403.4(A) RN2404.1(A) RN2404.2(A) RN2404.3(A) RN2404.4(A) RN2407.1(A) RN2407.2(A) RN2409.1(A) RN2409.2(A) RN2409.3(A) RN2409.4(A) RN2410.1(A) RN2410.2(A) RN2410.3(A) RN2410.4(A) RN2411.1(A) RN2411.2(A) RN2412.1(A) RN2412.2(A) RN2412.3(A) RN2412.4(A) RN2413.1(A) RN2413.2(A) U2401.5 U2401.19 U2401.22 U2401.43 U2401.65 U2401.82 U2401.103 U2401.115
+5V_AVDD: C2706.1 C2707.1 HDA27.20 R2703.1
+5V_KB_BL: C6501.1 F6501.2 KBBL1.1
+5V_PVDD: C2713.1 C2714.1 C2717.1 C2718.1 HDA27.34 HDA27.39 R2701.2 R2736.2
GND: AFTP2604.1 AFTP4306.1 AFTP4307.1 AFTP6403.1 AFTP6501.1 AFTP6531.1 AFTP6537.1 BATT1.8 BATT1.9 BATT1.10 BATT1.11 BATT1.12 BIOS1.4 BIOS2.4 BIOS2.9 C501.2 C801.2 C802.2 C803.2 C804.2 C805.1 C806.1 C807.2 C1102.2 C1103.2 C1104.2 C1105.2 C1106.2 C1107.2 C1108.2 C1109.2 C1110.2 C1111.2 C1112.2 C1113.2 C1114.2 C1115.2 C1116.2 C1117.2 C1118.2 C1119.2 C1120.2 C1121.2 C1122.2 C1123.2 C1128.2 C1129.2 C1130.2 C1131.2 C1132.2 C1133.2 C1134.2 C1135.2 C1136.2 C1137.2 C1138.2 C1139.2 C1140.2 C1141.2 C1142.2 C1202.2 C1203.2 C1204.2 C1205.2 C1206.2 C1207.2 C1208.2 C1209.2 C1210.2 C1214.2 C1215.2 C1216.2 C1217.2 C1218.2 C1219.2 C1220.2 C1221.2 C1223.2 C1225.2 C1226.2 C1227.2 C1228.2 C1229.2 C1231.2 C1301.2 C1303.2 C1304.2 C1305.2 C1306.2 C1307.2 C1308.2 C1309.2 C1310.2 C1311.2 C1313.2 C1315.2 C1316.2 C1317.2 C1318.2 C1319.2 C1320.2 C1321.2 C1322.2 C1324.2 C1325.2 C1326.2 C1327.2 C1328.2 C1329.2 C1701.2 C1702.2 C1703.2 C1711.2 C1803.2 C1804.2 C1805.2 C1806.2 C1807.1 C1808.1 C1809.2 C2201.2 C2202.2 C2203.2 C2204.2 C2205.2 C2206.2 C2207.2 C2208.2 C2209.2 C2210.2 C2211.2 C2212.2 C2213.2 C2214.2 C2215.2 C2216.2 C2217.2 C2218.2 C2219.2 C2220.2 C2221.2 C2222.2 C2223.2 C2224.2 C2225.2 C2226.2 C2227.2 C2228.2 C2229.2 C2230.2 C2231.2 C2405.2 C2406.2 C2407.2 C2408.2 C2409.2 C2410.2 C2411.2 C2412.2 C2413.2 C2414.2 C2416.2 C2418.2 C2420.2 C2421.2 C2422.2 C2423.2 C2424.1 C2425.1 C2426.2 C2428.2 C2429.2 C2431.2 C2432.2 C2435.2 C2501.2 C2502.2 C2503.2 C2517.2 C2525.2 C2601.2 C2602.2 C2603.2 C2604.2 C2605.2 C2610.2 C2612.2 C2613.2 C2614.2 C2704.2 C2705.2 C2709.2 C2713.2 C2714.2 C2717.2 C2718.2 C2720.2 C2721.2 C2722.2 C2723.2 C2736.2 C2740.2 C2741.2 C3103.2 C3108.2 C3110.2 C3112.2 C3115.2 C3116.2 C3117.2 C3118.2 C3119.2 C3120.2 C3121.2 C3122.2 C3123.2 C3124.2 C3125.2 C3126.2 C3202.2 C3203.2 C3507.2 C3516.2 C3517.2 C3518.2 C3519.2 C3524.2 C3525.2 C3526.2 C3527.2 C3602.2 C4001.2 C4002.2 C4004.2 C4005.2 C4006.2 C4007.2 C4008.2 C4009.2 C4010.2 C4011.2 C4012.2 C4013.2 C4014.2 C4015.2 C4017.2 C4031.2 C4032.2 C4033.2 C4034.2 C4035.2 C4036.2 C4041.2 C4043.2 C4302.2 C4303.2 C4304.2 C4305.2 C4306.2 C4344.2 C5503.2 C5504.2 C5505.2 C5512.2 C5513.2 C5514.2 C5516.2 C5517.2 C5520.2 C5528.2 C5529.2 C5530.2 C5531.2 C5535.2 C5536.2 C5538.2 C5539.2 C5540.2 C5541.2 C5599.2 C5736.1 C5809.1 C5810.1 C5811.2 C5812.2 C5813.2 C5863.2 C6007.2 C6008.2 C6018.2 C6019.2 C6102.2 C6104.2 C6105.2 C6106.2 C6304.2 C6305.2 C6306.2 C6307.2 C6308.2 C6317.2 C6318.2 C6401.1 C6405.2 C6501.2 C6505.2 C6506.2 C6510.2 C6511.2 C7003.2 C7004.2 C7115.1 C7116.1 C7117.1 C7118.1 C7119.2 C7120.2 C7165.1 C7166.1 C7201.1 C7202.2 C7203.2 C7204.2 C7205.2 C7206.2 C7207.2 C7208.2 C7209.2 C7210.2 C7211.2 C7212.2 C7213.2 C7214.2 C7215.1 C7216.2 C7217.2 C7302.2 C7303.2 C7304.2 C7305.2 C7306.2 C7307.2 C7403.2 C7404.2 C7405.2 C7610.2 C7611.2 C7612.2 C7613.2 C7614.2 C7615.2 C7616.2 C7620.2 C7621.2 C7622.2 C7623.2 C7624.2 C7625.2 C7626.2 C7627.2 C7628.2 C7629.2 C7630.2 C7631.2 C7632.2 C7633.2 C7634.2 C7744.2 C7745.2 C7746.2 C7801.2 C7802.2 C7805.2 C7807.2 C7808.2 C7809.2 C7810.2 C7811.2 C7812.2 C7813.2 C7814.2 C7817.2 C7818.2 C7819.2 C7820.2 C7821.2 C7822.2 C7823.2 C7824.2 C7825.2 C7826.2 C7827.2 C7828.2 C7829.2 C7902.2 C7905.2 C7906.2 C7907.1 C7908.1 C7934.2 C7935.2 C8001.2 C8002.2 C8003.2 C8004.2 C8008.2 C8009.2 C8010.2 C8011.2 C8012.2 C8013.2 C8014.2 C8015.2 C8016.2 C8017.2 C8018.2 C8019.2 C8020.2 C8021.2 C8022.2 C8023.2 C8024.2 C8025.2 C8026.2 C8028.2 C8029.2 C8030.2 C8031.2 C8032.2 C8034.2 C8035.2 C8036.2 C8038.2 C8039.2 C8040.2 C8041.2 C8042.2 C8043.2 C8047.2 C8048.2 C8049.2 C8050.2 C8051.2 C8101.2 C8102.2 C8103.2 C8104.2 C8105.2 C8106.2 C8107.2 C8108.2 C8109.2 C8110.2 C8111.2 C8112.2 C8113.2 C8114.2 C8115.2 C8116.2 C8117.2 C8118.2 C8119.2 C8120.2 C8121.2 C8122.2 C8123.2 C8124.2 C8125.2 C8126.2 C8127.2 C8128.2 C8129.2 C8130.2 C8131.2 C8132.2 C8136.2 C8140.2 C8141.2 C8142.2 C8143.2 C8144.2 C8145.2 C8146.2 C8501.2 C8502.2 C8601.2 C8603.2 C8605.2 C8608.2 C8625.2 C8626.2 C8627.2 C8802.2 C8803.2 C8804.2 C8805.2 C8806.2 C8807.2 C8808.2 C8809.2 C9104.2 C9106.2 C9108.2 C9109.2 C9112.2 C9113.2 C9201.2 C9202.2 C9203.2 CPU1.A3 CPU1.A4 CPU1.A32 CPU1.A36 CPU1.AB3 CPU1.AB4 CPU1.AB7 CPU1.AB27 CPU1.AB30 CPU1.AB33 CPU1.AB36 CPU1.AC5 CPU1.AC10 CPU1.AC27 CPU1.AC30 CPU1.AD33 CPU1.AD35 CPU1.AE7 CPU1.AE24 CPU1.AE25 CPU1.AE26 CPU1.AE27 CPU1.AE30 CPU1.AF3 CPU1.AF4 CPU1.AF7 CPU1.AF25 CPU1.AF27 CPU1.AF30 CPU1.AF33 CPU1.AF36 CPU1.AG5 CPU1.AG10 CPU1.AG24 CPU1.AG26 CPU1.AH24 CPU1.AH25 CPU1.AH27 CPU1.AH28 CPU1.AH29 CPU1.AH30 CPU1.AH31 CPU1.AH33 CPU1.AH35 CPU1.AJ7 CPU1.AJ25 CPU1.AJ28 CPU1.AK3 CPU1.AK4 CPU1.AK33 CPU1.AK36 CPU1.AL7 CPU1.AL28 CPU1.AL29 CPU1.AL32 CPU1.AM5 CPU1.AM10 CPU1.AM28 CPU1.AM33 CPU1.AM35 CPU1.AN7 CPU1.AN8 CPU1.AN25 CPU1.AN28 CPU1.AN29 CPU1.AN30 CPU1.AN31 CPU1.AP3 CPU1.AP4 CPU1.AP33 CPU1.AP36 CPU1.AR4 CPU1.AR28 CPU1.AT4 CPU1.AT33 CPU1.AT35 CPU1.AT36 CPU1.AU4 CPU1.AU10 CPU1.AU28 CPU1.AU29 CPU1.AU32 CPU1.AV3 CPU1.AV4 CPU1.AV6 CPU1.AV8 CPU1.AV25 CPU1.AV28 CPU1.AV33 CPU1.AV36 CPU1.AW1 CPU1.AW3 CPU1.AW4 CPU1.AW28 CPU1.AW29 CPU1.AW30 CPU1.AW31 CPU1.AY4 CPU1.AY33 CPU1.AY35 CPU1.B2 CPU1.B5 CPU1.B7 CPU1.B9 CPU1.B12 CPU1.B15 CPU1.B18 CPU1.B21 CPU1.B23 CPU1.B25 CPU1.B27 CPU1.B29 CPU1.B31 CPU1.B34 CPU1.B36 CPU1.B37 CPU1.BA3 CPU1.BA4 CPU1.BA6 CPU1.BA10 CPU1.BA28 CPU1.BB3 CPU1.BB4 CPU1.BB33 CPU1.BB36 CPU1.BC4 CPU1.BC8 CPU1.BC25 CPU1.BC29 CPU1.BC32 CPU1.BD4 CPU1.BD6 CPU1.BD7 CPU1.BD28 CPU1.BD33 CPU1.BD35 CPU1.BD36 CPU1.BE3 CPU1.BE4 CPU1.BE8 CPU1.BE10 CPU1.BE28 CPU1.BE29 CPU1.BE30 CPU1.BE31 CPU1.BF3 CPU1.BF4 CPU1.BF33 CPU1.BF36 CPU1.BG4 CPU1.BG25 CPU1.BG28 CPU1.BH28 CPU1.BH29 CPU1.BH32 CPU1.BH33 CPU1.BH35 CPU1.BJ7 CPU1.BK2 CPU1.BK3 CPU1.BK4 CPU1.BK7 CPU1.BK10 CPU1.BK28 CPU1.BK33 CPU1.BL7 CPU1.BL25 CPU1.BL28 CPU1.BL29 CPU1.BL30 CPU1.BL31 CPU1.BL32 CPU1.BM9 CPU1.BM33 CPU1.BM35 CPU1.BM36 CPU1.BN7 CPU1.BN30 CPU1.BP3 CPU1.BP4 CPU1.BP7 CPU1.BP12 CPU1.BP15 CPU1.BP19 CPU1.BP25 CPU1.BP32 CPU1.BP33 CPU1.BP36 CPU1.BR16 CPU1.BR19 CPU1.BR22 CPU1.BR25 CPU1.BT5 CPU1.BT14 CPU1.BT15 CPU1.BT16 CPU1.BT25 CPU1.BT28 CPU1.BT33 CPU1.BT35 CPU1.BT36 CPU1.BU7 CPU1.BU11 CPU1.BU16 CPU1.BU20 CPU1.BU23 CPU1.BU24 CPU1.BU25 CPU1.BV3 CPU1.BV4 CPU1.BV11 CPU1.BV31 CPU1.BV33 CPU1.BW7 CPU1.BW11 CPU1.BW15 CPU1.BW24 CPU1.BY5 CPU1.BY11 CPU1.BY15 CPU1.BY18 CPU1.BY19 CPU1.BY22 CPU1.BY25 CPU1.BY28 CPU1.BY33 CPU1.BY35 CPU1.BY36 CPU1.C1 CPU1.C4 CPU1.C9 CPU1.C21 CPU1.C25 CPU1.C29 CPU1.C33 CPU1.C36 CPU1.C37 CPU1.CA11 CPU1.CA15 CPU1.CA22 CPU1.CA25 CPU1.CB2 CPU1.CB3 CPU1.CB4 CPU1.CB7 CPU1.CB11 CPU1.CB18 CPU1.CB19 CPU1.CB20 CPU1.CB24 CPU1.CB25 CPU1.CB33 CPU1.CC7 CPU1.CC11 CPU1.CC14 CPU1.CC16 CPU1.CC20 CPU1.CC24 CPU1.CC25 CPU1.CC28 CPU1.CC31 CPU1.CD11 CPU1.CD12 CPU1.CD14 CPU1.CD20 CPU1.CD24 CPU1.CD25 CPU1.CE7 CPU1.CE33 CPU1.CE35 CPU1.CE36 CPU1.CF2 CPU1.CF3 CPU1.CF4 CPU1.CF11 CPU1.CF14 CPU1.CF19 CPU1.CF23 CPU1.CF28 CPU1.CG7 CPU1.CG33 CPU1.CH31 CPU1.CJ2 CPU1.CJ3 CPU1.CJ4 CPU1.CJ11 CPU1.CJ14 CPU1.CJ19 CPU1.CJ23 CPU1.CJ28 CPU1.CJ33 CPU1.CJ35 CPU1.CJ36 CPU1.CK1 CPU1.CK4 CPU1.CK7 CPU1.CK37 CPU1.CL2 CPU1.CM1 CPU1.CM4 CPU1.CM5 CPU1.CM9 CPU1.CM13 CPU1.CM17 CPU1.CM21 CPU1.CM25 CPU1.CM29 CPU1.CM31 CPU1.CM33 CPU1.CM37 CPU1.CN1 CPU1.CN2 CPU1.CN5 CPU1.CN9 CPU1.CN13 CPU1.CN17 CPU1.CN21 CPU1.CN25 CPU1.CN29 CPU1.CN37 CPU1.CP1 CPU1.CP2 CPU1.CP9 CPU1.CP11 CPU1.CP13 CPU1.CP15 CPU1.CP19 CPU1.CP21 CPU1.CP27 CPU1.CP35 CPU1.CP37 CPU1.CR2 CPU1.CR6 CPU1.CR34 CPU1.CR36 CPU1.D1 CPU1.D5 CPU1.D6 CPU1.D8 CPU1.D9 CPU1.D21 CPU1.D25 CPU1.E9 CPU1.E23 CPU1.E27 CPU1.E29 CPU1.E31 CPU1.E33 CPU1.E35 CPU1.F2 CPU1.F3 CPU1.F4 CPU1.F12 CPU1.F15 CPU1.F18 CPU1.F21 CPU1.F24 CPU1.F33 CPU1.G9 CPU1.G21 CPU1.G27 CPU1.G33 CPU1.G35 CPU1.G36 CPU1.H9 CPU1.H21 CPU1.H27 CPU1.J5 CPU1.J6 CPU1.J12 CPU1.J15 CPU1.J18 CPU1.J21 CPU1.J24 CPU1.J33 CPU1.J36 CPU1.K3 CPU1.K4 CPU1.K9 CPU1.K21 CPU1.K22 CPU1.K24 CPU1.K25 CPU1.K27 CPU1.K28 CPU1.K29 CPU1.K30 CPU1.K31 CPU1.K32 CPU1.L6 CPU1.L27 CPU1.L33 CPU1.L35 CPU1.L36 CPU1.N6 CPU1.N25 CPU1.N27 CPU1.P3 CPU1.P4 CPU1.P7 CPU1.P10 CPU1.P33 CPU1.P36 CPU1.R27 CPU1.R28 CPU1.R29 CPU1.R30 CPU1.R31 CPU1.T7 CPU1.T27 CPU1.T30 CPU1.T33 CPU1.T35 CPU1.T36 CPU1.U7 CPU1.U24 CPU1.U26 CPU1.V3 CPU1.V4 CPU1.V26 CPU1.V27 CPU1.V30 CPU1.V33 CPU1.V36 CPU1.W7 CPU1.W10 CPU1.W27 CPU1.W30 CPU1.Y7 CPU1.Y26 CPU1.Y27 CPU1.Y30 CPU1.Y33 CPU1.Y35 D2601.A D4301.A D4302.1 D4304.A DBEC1.4 DBEC1.7 DBEC1.8 DBG1.3 DBG1.15 DBG1.16 DCIN1.9 DCIN1.10 DM1.1 DM1.2 DM1.5 DM1.6 DM1.9 DM1.10 DM1.14 DM1.15 DM1.18 DM1.19 DM1.22 DM1.23 DM1.26 DM1.27 DM1.30 DM1.31 DM1.35 DM1.36 DM1.39 DM1.40 DM1.43 DM1.44 DM1.47 DM1.48 DM1.51 DM1.52 DM1.56 DM1.57 DM1.60 DM1.61 DM1.64 DM1.65 DM1.68 DM1.69 DM1.72 DM1.73 DM1.77 DM1.78 DM1.81 DM1.82 DM1.85 DM1.86 DM1.89 DM1.90 DM1.93 DM1.94 DM1.98 DM1.99 DM1.102 DM1.103 DM1.106 DM1.107 DM1.167 DM1.168 DM1.171 DM1.172 DM1.175 DM1.176 DM1.180 DM1.181 DM1.184 DM1.185 DM1.188 DM1.189 DM1.192 DM1.193 DM1.196 DM1.197 DM1.201 DM1.202 DM1.205 DM1.206 DM1.209 DM1.210 DM1.213 DM1.214 DM1.217 DM1.218 DM1.222 DM1.223 DM1.226 DM1.227 DM1.230 DM1.231 DM1.234 DM1.235 DM1.238 DM1.239 DM1.243 DM1.244 DM1.247 DM1.248 DM1.251 DM1.252 DM1.261 DM1.262 DM2.1 DM2.2 DM2.5 DM2.6 DM2.9 DM2.10 DM2.14 DM2.15 DM2.18 DM2.19 DM2.22 DM2.23 DM2.26 DM2.27 DM2.30 DM2.31 DM2.35 DM2.36 DM2.39 DM2.40 DM2.43 DM2.44 DM2.47 DM2.48 DM2.51 DM2.52 DM2.56 DM2.57 DM2.60 DM2.61 DM2.64 DM2.65 DM2.68 DM2.69 DM2.72 DM2.73 DM2.77 DM2.78 DM2.81 DM2.82 DM2.85 DM2.86 DM2.89 DM2.90 DM2.93 DM2.94 DM2.98 DM2.99 DM2.102 DM2.103 DM2.106 DM2.107 DM2.167 DM2.168 DM2.171 DM2.172 DM2.175 DM2.176 DM2.180 DM2.181 DM2.184 DM2.185 DM2.188 DM2.189 DM2.192 DM2.193 DM2.196 DM2.197 DM2.201 DM2.202 DM2.205 DM2.206 DM2.209 DM2.210 DM2.213 DM2.214 DM2.217 DM2.218 DM2.222 DM2.223 DM2.226 DM2.227 DM2.230 DM2.231 DM2.234 DM2.235 DM2.238 DM2.239 DM2.243 DM2.244 DM2.247 DM2.248 DM2.251 DM2.252 DM2.261 DM2.262 EC1202.2 EC1203.2 EC1303.2 EC1707.2 EC1712.2 EC1801.2 EC1803.1 EC1901.1 EC1903.2 EC2002.2 EC2201.2 EC2501.2 EC2502.2 EC2503.2 EC2504.2 EC2505.2 EC2506.2 EC2601.2 EC2602.2 EC2701.2 EC2702.2 EC2703.2 EC2704.2 EC2705.2 EC2706.2 EC2707.2 EC2708.2 EC2901.2 EC2902.2 EC2903.2 EC2904.2 EC3513.2 EC4306.1 EC4307.2 EC4308.2 EC4309.2 EC4310.2 EC4311.2 EC4534.1 EC4701.2 EC5001.2 EC5503.2 EC5504.2 EC6401.2 EC6402.2 EC6403.2 EC6404.2 EC6405.2 EC6501.2 EC6502.2 EC6503.2 EC6504.2 EC6601.2 EC8901.2 EC8902.2 EC8903.2 EC8904.2 EC8905.2 EC8906.2 EC8907.2 EC8908.2 EC8909.2 EC8910.2 EC8911.2 EC8912.2 EC8913.2 EC8914.2 EC8915.2 EC8923.2 EC8924.2 EC8925.2 EC8927.2 EC8929.2 EC8930.2 EC8932.2 EC8933.2 EC8934.2 EC8935.2 EC8936.2 EC8937.2 EC8938.2 EC8939.2 EC8940.2 EC8941.2 EC8942.2 EC8943.2 EC8944.2 EC8945.2 EC8946.2 EC8947.2 EC8948.2 EC8949.2 EC8950.2 EC8951.2 EC8952.2 EC8953.2 EC8955.2 EC8957.2 EC8959.2 EC8960.2 EC8961.2 EC8962.2 EC8963.1 EC8964.1 EC8965.2 EC8966.2 EC8967.2 EC8968.2 EC8969.2 EC8971.2 EC8972.2 EC8973.2 EC8974.2 EC8975.2 EC8976.2 EC8977.2 EC8978.2 EC8979.2 EC8980.2 EC8986.2 EC8987.2 EC8988.2 EC8989.2 EC8990.2 EC8991.2 EC8992.2 EC8993.2 EC8994.2 EC8995.2 EC8996.2 EC8997.2 EC8998.2 EC8999.2 EC9001.2 ED301.3 ED1217.3 ED1302.3 ED1701.1 ED1702.1 ED1703.1 ED1705.1 ED1706.1 ED1707.1 ED1801.1 ED1802.1 ED2403.3 ED2910.3 ED2911.3 ED2912.3 ED3201.3 ED3201.8 ED3202.3 ED3202.8 ED3501.3 ED3501.8 ED3502.2 ED3503.3 ED3503.8 ED4303.1 ED4304.1 ED4305.1 ED4306.1 ED5502.2 ED5701.3 ED5701.8 ED5702.3 ED5702.8 ED5703.3 ED5703.8 ED6001.3 ED6001.8 ED6401.3 ED6601.2 ED7301.3 ED7301.8 ED7302.3 ED7302.8 ED7307.3 ED7311.1 ED7312.1 ED7313.1 ED7314.1 ED7315.3 ED9202.2 EL4303.2 EL4304.2 FAN1.2 FAN1.5 FAN1.6 FC1102.2 FC1103.2 FC8901.2 FC8902.2 FC8903.2 FC8904.2 FC8905.2 FC8906.2 FC8907.2 FC8908.2 FC8909.2 FC8910.2 FC8911.2 FC8912.2 FC8913.2 FC8914.2 FC8915.2 FC8916.2 FC8917.2 FC8918.2 FC8919.2 FC8921.2 FC8922.2 FC8923.2 FC8924.2 FC8929.2 FC8930.2 FC8931.2 FC8932.2 FC8933.2 FC8934.2 FC8935.2 FC8936.2 FC8937.2 FC8938.2 FC8939.2 FC8940.2 FC8941.2 FC8942.2 FC8944.2 FC8945.2 FC8946.2 FC8947.2 FC8948.2 FC8951.2 FC8952.2 FC8953.2 FC8954.2 FC8955.2 FC8956.2 FC8957.2 FC8958.2 FC8959.2 FC8960.2 FC8961.2 FC8962.2 FC8963.2 FC8964.2 FC8965.2 FC8966.2 FC8967.2 FC8970.2 FC8981.2 FC8983.2 FC8984.2 FC8985.2 FC8986.2 FC8987.2 FC8988.2 FC8990.2 FC8991.2 FC8992.2 FC8993.2 FC8994.2 FC8995.2 FC8996.2 FC8997.2 FC8998.2 FC8999.2 FC9001.2 FC9002.2 FC9003.2 FC9004.2 FC9005.2 FC9006.2 FP1.5 FP1.8 FP1.9 FP1.10 G1801.1 G6401.2 G6402.2 GPU1.A2 GPU1.A26 GPU1.AA7 GPU1.AB7 GPU1.AB11 GPU1.AB14 GPU1.AB17 GPU1.AB20 GPU1.AB24 GPU1.AC2 GPU1.AC5 GPU1.AC8 GPU1.AC22 GPU1.AC26 GPU1.AD12 GPU1.AD13 GPU1.AD15 GPU1.AD16 GPU1.AD18 GPU1.AD19 GPU1.AD21 GPU1.AD22 GPU1.AE11 GPU1.AE14 GPU1.AE17 GPU1.AE20 GPU1.AF1 GPU1.AF5 GPU1.AF8 GPU1.AF11 GPU1.AF14 GPU1.AF17 GPU1.AF20 GPU1.AF23 GPU1.AG2 GPU1.AG26 GPU1.B1 GPU1.B5 GPU1.B8 GPU1.B11 GPU1.B14 GPU1.B17 GPU1.B20 GPU1.B23 GPU1.B27 GPU1.E2 GPU1.E5 GPU1.E8 GPU1.E11 GPU1.E14 GPU1.E17 GPU1.E20 GPU1.E22 GPU1.E25 GPU1.H2 GPU1.H5 GPU1.H23 GPU1.H25 GPU1.K11 GPU1.K13 GPU1.K15 GPU1.K17 GPU1.L2 GPU1.L5 GPU1.L10 GPU1.L12 GPU1.L14 GPU1.L16 GPU1.L18 GPU1.L23 GPU1.L25 GPU1.M11 GPU1.M13 GPU1.M15 GPU1.M17 GPU1.N10 GPU1.N12 GPU1.N14 GPU1.N16 GPU1.N18 GPU1.P2 GPU1.P5 GPU1.P11 GPU1.P13 GPU1.P15 GPU1.P17 GPU1.P23 GPU1.P26 GPU1.R10 GPU1.R12 GPU1.R14 GPU1.R16 GPU1.R18 GPU1.T11 GPU1.T13 GPU1.T15 GPU1.T17 GPU1.U2 GPU1.U5 GPU1.U10 GPU1.U12 GPU1.U14 GPU1.U16 GPU1.U18 GPU1.U23 GPU1.U26 GPU1.V11 GPU1.V13 GPU1.V15 GPU1.V17 GPU1.Y2 GPU1.Y5 GPU1.Y23 GPU1.Y26 H1.1 H2.1 H3.1 H4.1 H5.1 H6.1 H7.1 H9.1 H10.1 H11.1 H12.1 H13.1 H14.1 H16.1 H17.1 H18.1 HDA27.41 HDD1.1 HDD1.2 HDD1.3 HDD1.4 HDD1.14 HDD1.17 HDD1.20 HDD1.21 HDD1.22 HDD1.23 HDD1.24 HDD2.1 HDD2.4 HDD2.7 HDD2.13 HDD2.14 HDMI1.2 HDMI1.5 HDMI1.8 HDMI1.11 HDMI1.17 HDMI1.20 HDMI1.21 HDMI1.22 HDMI1.23 HS3.1 IOBD1.1 IOBD1.4 IOBD1.7 IOBD1.10 IOBD1.21 IOBD1.22 JUSB1.13 JUSB1.14 JUSB1.15 JUSB1.16 JUSB1.17 JUSB1.18 JUSB1.19 JUSB1.20 JUSB1.21 JUSB1.22 JUSB1.A1 JUSB1.A12 JUSB1.B1 JUSB1.B12 KB1.1 KB1.31 KB1.32 KBBL1.5 KBBL1.6 LCD1.1 LCD1.4 LCD1.7 LCD1.11 LCD1.17 LCD1.41 LCD1.42 LCD1.43 LCD1.44 LED1.3 MESW1.4 MESW1.5 MESW1.6 MESW1.7 ODD1.3 ODD1.6 ODD1.9 ODD1.10 ODD1.17 ODD1.18 PC1001.2 PC1002.2 PC1003.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1008.2 PC1009.2 PC1010.2 PC1011.2 PC1012.2 PC1013.2 PC1014.2 PC1015.2 PC1016.2 PC1017.2 PC1018.2 PC1019.2 PC1020.2 PC1021.2 PC1022.2 PC1023.2 PC1024.2 PC1025.2 PC1026.2 PC1027.2 PC1028.2 PC1029.2 PC1030.2 PC1031.2 PC1032.2 PC1034.2 PC1036.2 PC1037.2 PC1038.2 PC1039.2 PC1040.2 PC1041.2 PC1042.2 PC1043.2 PC1044.2 PC1045.2 PC1046.2 PC1047.2 PC1048.2 PC1049.2 PC1050.2 PC1051.2 PC1052.2 PC1053.2 PC1054.2 PC1055.2 PC1056.2 PC1057.2 PC1058.2 PC1059.2 PC1060.2 PC1061.2 PC1062.2 PC1063.2 PC1064.2 PC1065.2 PC1066.2 PC1067.2 PC1068.2 PC1069.2 PC1070.2 PC1071.2 PC1072.2 PC1073.2 PC1074.2 PC1075.2 PC1076.2 PC1077.2 PC1078.2 PC1079.2 PC1080.2 PC1081.2 PC1082.2 PC1083.2 PC1084.2 PC4402.2 PC4403.2 PC4404.2 PC4405.2 PC4406.2 PC4407.2 PC4408.2 PC4409.2 PC4410.2 PC4411.2 PC4412.2 PC4413.2 PC4414.2 PC4416.1 PC4417.1 PC4418.2 PC4419.2 PC4420.1 PC4421.2 PC4422.2 PC4424.1 PC4426.1 PC4427.2 PC4429.2 PC4430.2 PC4431.2 PC4432.2 PC4433.2 PC4434.2 PC4435.2 PC4437.2 PC4439.1 PC4440.1 PC4441.2 PC4446.2 PC4447.2 PC4448.2 PC4501.2 PC4502.2 PC4503.2 PC4504.2 PC4505.2 PC4507.2 PC4508.2 PC4509.2 PC4510.2 PC4511.2 PC4512.2 PC4513.2 PC4514.2 PC4515.2 PC4516.2 PC4517.2 PC4518.2 PC4519.2 PC4520.2 PC4522.2 PC4523.2 PC4524.2 PC4525.2 PC4527.2 PC4529.2 PC4530.2 PC4531.2 PC4532.2 PC4601.2 PC4602.2 PC4603.1 PC4604.1 PC4606.2 PC4607.2 PC4610.1 PC4612.2 PC4613.2 PC4614.2 PC4615.1 PC4620.2 PC4621.1 PC4622.2 PC4624.2 PC4629.1 PC4631.2 PC4633.2 PC4637.2 PC4638.2 PC4639.2 PC4640.2 PC4641.2 PC4644.2 PC4651.2 PC4701.2 PC4702.2 PC4703.2 PC4704.2 PC4706.2 PC4708.2 PC4766.2 PC4802.2 PC4803.2 PC4804.2 PC4805.2 PC4809.2 PC4810.2 PC4812.2 PC4813.2 PC4814.2 PC4815.2 PC4816.2 PC4817.2 PC4866.2 PC4877.2 PC5001.2 PC5002.2 PC5003.2 PC5004.2 PC5103.2 PC5104.2 PC5105.2 PC5106.2 PC5107.2 PC5112.2 PC5113.2 PC5114.2 PC5115.2 PC5116.2 PC5117.2 PC5118.2 PC5119.2 PC5120.2 PC5121.2 PC5122.2 PC5123.2 PC5124.2 PC5127.2 PC5201.2 PC5202.2 PC5203.2 PC5205.2 PC5206.2 PC5208.2 PC5209.2 PC5210.2 PC5211.2 PC5213.2 PC5214.2 PC5215.2 PC5216.2 PC5217.2 PC5301.2 PC5302.2 PC5303.2 PC5307.2 PC8501.2 PC8502.2 PC8503.2 PC8504.2 PC8505.2 PC8506.2 PC8507.2 PC8508.2 PC8550.2 PC8551.1 PC8552.1 PC8556.2 PC8559.2 PC8560.2 PC8561.2 PC8562.2 PC8573.2 PC8576.2 PC8578.2 PC8609.2 PC8610.2 PC8611.2 PC8613.2 PC8614.2 PC8615.2 PC8617.2 PC8618.2 PC8620.2 PC8621.2 PC8627.2 PC8628.2 PC8629.2 PC8630.2 PC8631.2 PC8633.2 PC8634.2 PD5101.A PQ4402.S PQ4405.1 PQ4405.4 PQ4415.1 PQ4415.4 PQ4416.1 PQ4416.4 PQ4417.S PQ4418.1 PQ4418.4 PR4406.2 PR4410.1 PR4413.2 PR4417.1 PR4426.2 PR4436.2 PR4447.2 PR4451.2 PR4453.1 PR4474.1 PR4475.2 PR4485.2 PR4492.2 PR4494.2 PR4497.1 PR4508.2 PR4512.2 PR4513.2 PR4514.2 PR4551.2 PR4608.1 PR4614.2 PR4617.2 PR4621.1 PR4627.1 PR4628.2 PR4629.2 PR4639.2 PR4644.2 PR4654.2 PR4655.1 PR4659.1 PR4661.2 PR5104.2 PR5109.2 PR5114.2 PR5120.2 PR5203.2 PR5204.2 PR5304.2 PR8505.2 PR8508.2 PR8564.2 PR8573.2 PR8620.2 PR8626.2 PR8632.1 PT4701.2 PT4702.2 PT4801.2 PT4803.2 PT4807.2 PT4808.2 PT8508.2 PT8511.2 PT8512.2 PU4401.33 PU4404.1 PU4404.2 PU4404.3 PU4406.1 PU4406.2 PU4406.3 PU4501.7 PU4501.8 PU4501.18 PU4501.21 PU4502.7 PU4502.8 PU4502.18 PU4502.21 PU4601.41 PU4701.12 PU4701.13 PU4701.14 PU4701.15 PU4701.28 PU4701.32 PU4701.34 PU4801.12 PU4801.13 PU4801.14 PU4801.15 PU4801.28 PU4801.32 PU4801.34 PU4802.12 PU4802.13 PU4802.14 PU4802.15 PU4802.28 PU4802.32 PU4802.34 PU5001.4 PU5001.9 PU5003.1 PU5003.2 PU5003.3 PU5101.1 PU5102.4 PU5102.11 PU5102.12 PU5102.13 PU5102.14 PU5102.15 PU5102.16 PU5102.30 PU5102.32 PU5102.33 PU5201.4 PU5201.12 PU5201.13 PU5201.14 PU5201.15 PU5201.19 PU5301.4 PU5301.8 PU5301.9 PU8510.5 PU8510.6 PU8510.7 PU8512.5 PU8512.6 PU8512.7 PU8514.21 PU8515.5 PU8515.6 PU8515.7 PU8516.5 PU8516.6 PU8516.7 PU8602.7 PU8602.8 PU8602.18 PU8602.21 PU8603.4 PU8603.8 PU8603.9 PWR1.5 PWR1.7 PWR1.8 Q401.1 Q401.4 Q501.S Q502.S Q1701.1 Q1701.4 Q1702.1 Q1702.4 Q2408.S Q2505.S Q2510.S Q4302.E Q4304.E Q4449.1 Q4449.4 Q5504.2 Q5505.2 Q5701.S Q6501.S Q6503.S Q7001.1 Q7001.4 Q7201.S Q7404.1 Q7404.4 Q7405.4 Q7406.1 Q7406.4 Q7407.1 Q7407.4 Q7408.S Q7907.1 Q7907.4 Q8101.S Q8701.1 Q8701.4 Q8702.1 Q8702.4 Q8703.1 Q8703.4 Q8704.1 Q8704.4 Q8705.1 Q8705.4 Q9202.S R304.2 R305.2 R316.2 R317.2 R318.2 R403.1 R501.2 R502.2 R503.2 R601.2 R708.2 R808.2 R809.2 R1205.2 R1209.2 R1210.2 R1212.2 R1216.2 R1303.2 R1307.2 R1309.2 R1311.2 R1516.2 R1517.2 R1518.2 R1521.2 R1603.2 R1714.2 R1715.2 R1717.2 R1719.2 R1803.2 R1817.2 R1901.2 R1911.2 R2007.2 R2009.2 R2054.1 R2063.2 R2101.2 R2108.2 R2112.2 R2114.2 R2116.2 R2118.2 R2417.2 R2426.1 R2436.2 R2441.2 R2444.2 R2448.2 R2449.1 R2454.2 R2465.2 R2504.2 R2517.2 R2518.2 R2610.2 R2704.2 R2705.2 R2735.2 R3102.2 R3113.2 R3603.1 R3604.1 R4006.2 R4301.1 R4302.2 R4308.2 R4312.2 R4315.1 R4316.2 R4377.2 R5544.1 R5549.1 R5552.2 R5555.2 R5764.2 R5782.2 R5804.2 R5808.1 R5810.1 R5812.1 R5814.1 R5816.1 R5818.2 R5819.2 R5823.1 R6101.2 R6121.2 R6122.2 R6413.1 R6508.2 R6804.2 R7007.1 R7011.2 R7102.1 R7129.1 R7130.1 R7141.2 R7143.2 R7144.2 R7146.2 R7170.2 R7172.2 R7173.2 R7185.2 R7186.2 R7187.2 R7188.2 R7213.1 R7214.2 R7218.2 R7219.2 R7330.1 R7331.1 R7404.2 R7405.1 R7415.2 R7418.2 R7422.2 R7428.2 R7429.2 R7430.2 R7431.2 R7432.2 R7601.2 R7602.2 R7606.2 R7614.2 R7806.2 R7807.2 R7818.2 R7820.1 R7821.1 R7901.2 R7902.2 R7907.1 R7908.2 R7910.2 R7911.2 R7915.2 R7921.2 R7923.1 R7924.2 R7926.2 R7927.2 R7929.2 R7932.2 R7939.2 R7944.2 R8103.2 R8106.2 R8107.2 R8108.2 R8109.1 R8110.1 R8112.1 R8604.2 R9101.1 RJ1.9 RJ1.10 RJ1.11 RJ1.12 RN1201.2(A) RN1301.2(A) RN1602.3(B) RN1602.4(B) RN1703.1(A) RN1703.2(A) RN5502.5(B) RN5502.6(B) RN5502.7(B) RN5502.8(B) RN7701.3(B) RN7701.4(B) SPK1.5 SPK1.6 SPR3.1 SPR4.1 SSD1.1 SSD1.3 SSD1.9 SSD1.15 SSD1.21 SSD1.27 SSD1.33 SSD1.39 SSD1.45 SSD1.51 SSD1.57 SSD1.71 SSD1.73 SSD1.75 SSD1.76 SSD1.77 TP1.5 TP1.9 TP1.10 U2401.17 U2401.51 U2401.64 U2401.84 U2401.100 U2401.112 U2401.124 U2402.3 U2502.2 U2601.5 U3101.33 U3502.2 U3601.14 U3601.17 U4001.11 U4001.15 U4002.5 U4003.5 U4004.11 U4004.15 U4006.5 U4007.3 U4302.3 U5501.2 U5503.11 U5503.15 U5702.1 U5802.11 U5802.19 U5802.52 U5802.61 U6101.2 U7001.5 U7001.6 U7001.7 U7001.8 U7101.41 U7102.5 U7102.21 U7201.19 U7201.25 U7202.1 U7202.7 U7203.3 U7203.7 U7302.3 U7403.B3 U7403.C3 U7403.D3 U7419.B3 U7419.C3 U7419.D3 U7419.E3 U7601.3 U7602.3 U8601.11 U8601.15 U8801.3 U8802.3 U8803.3 U8804.3 U9103.16 U9103.23 U9103.33 USB1.4 USB1.7 USB1.10 USB1.11 USB1.12 USB1.13 USB2.4 USB2.7 USB2.10 USB2.11 USB2.12 USB2.13 VGABD1.6 VGABD1.9 VGABD1.12 VGABD1.15 VGABD1.20 VGABD1.21 VGABD1.22 VGABD1.23 VGABD1.24 VRAM1.A1 VRAM1.A3 VRAM1.A12 VRAM1.A14 VRAM1.B5 VRAM1.B10 VRAM1.C1 VRAM1.C3 VRAM1.C4 VRAM1.C11 VRAM1.C12 VRAM1.C14 VRAM1.D10 VRAM1.E1 VRAM1.E3 VRAM1.E12 VRAM1.E14 VRAM1.F5 VRAM1.F10 VRAM1.G5 VRAM1.G10 VRAM1.H1 VRAM1.H2 VRAM1.H13 VRAM1.H14 VRAM1.K1 VRAM1.K2 VRAM1.K13 VRAM1.K14 VRAM1.L5 VRAM1.L10 VRAM1.M5 VRAM1.M10 VRAM1.N1 VRAM1.N3 VRAM1.N12 VRAM1.N14 VRAM1.P10 VRAM1.R1 VRAM1.R3 VRAM1.R4 VRAM1.R11 VRAM1.R12 VRAM1.R14 VRAM1.T5 VRAM1.T10 VRAM1.U1 VRAM1.U3 VRAM1.U12 VRAM1.U14 VRAM4.A1 VRAM4.A3 VRAM4.A12 VRAM4.A14 VRAM4.B5 VRAM4.B10 VRAM4.C1 VRAM4.C3 VRAM4.C4 VRAM4.C11 VRAM4.C12 VRAM4.C14 VRAM4.D10 VRAM4.E1 VRAM4.E3 VRAM4.E12 VRAM4.E14 VRAM4.F5 VRAM4.F10 VRAM4.G5 VRAM4.G10 VRAM4.H1 VRAM4.H2 VRAM4.H13 VRAM4.H14 VRAM4.K1 VRAM4.K2 VRAM4.K13 VRAM4.K14 VRAM4.L5 VRAM4.L10 VRAM4.M5 VRAM4.M10 VRAM4.N1 VRAM4.N3 VRAM4.N12 VRAM4.N14 VRAM4.P10 VRAM4.R1 VRAM4.R3 VRAM4.R4 VRAM4.R11 VRAM4.R12 VRAM4.R14 VRAM4.T5 VRAM4.T10 VRAM4.U1 VRAM4.U3 VRAM4.U12 VRAM4.U14 WLAN1.1 WLAN1.7 WLAN1.13 WLAN1.18 WLAN1.19 WLAN1.33 WLAN1.39 WLAN1.45 WLAN1.51 WLAN1.57 WLAN1.63 WLAN1.69 WLAN1.75 WLAN1.76 WLAN1.77 WWAN1.7 WWAN1.18 WWAN1.22 WWAN1.25 WWAN1.28 WWAN1.31 WWAN1.34 WWAN1.35 WWAN1.36 X3101.2 X3101.4 X7901.2 X7901.4
V0.85A_VID0: CPU1.CB36 TP2201.1
V0.85A_VID1: CPU1.CB35 TP2202.1
V3D3_STB: HDA27.16 R2708.2
VBUS_P_CTRL: Q7404.2 R7405.2 U7201.14 U7403.B4
VBUS_P_CTRL_R: Q7404.5 Q7404.6 R7423.2 R7430.1
VCC3PD: D7201.K D7202.K R7204.1 R7210.1 R7433.1
VCCCORE_SENSE: CPU1.AN6 PR4665.1 R707.2
VCCDSW_ON: C2525.1 D2503.2 R2520.2 U2401.88
VCCGT_SENSE: CPU1.E3 PR4667.1 R807.2
VCCPD_VBUS_ACK: PR4430.2 R7424.2 U7419.A2
VCCRTCEXT: C2201.1 CPU1.BP24
VCCSA_SENSE: CPU1.BG7 PR4601.2 R810.2
VCCST_PWRGD_R: C1711.1 CPU1.BJ2 ED1707.2 R1716.2 R1719.1
VCCSTG_EN_R1: C4033.1 R4017.2 U4002.4 U4003.4 U4007.4
VCCSTU_EN_R: C4034.1 R4024.2 U4006.4
VDD: PC4422.1 PR4405.2 PR4427.1 PR4429.1 PR4448.1 PR4449.1 PU4401.18
VDD10: C3108.1 C3112.1 C3115.1 C3119.1 C3120.1 C3122.1 C3123.1 C3126.1 R3101.2 U3101.3 U3101.8 U3101.22 U3101.30
VDDD: C7203.1 C7204.1 C7207.1 R7202.1 R7204.2 R7211.2 R7212.1 RN7201.1(A) RN7201.2(A) RN7202.1(A) RN7202.2(A) U7201.20
VDDIO: C7210.1 C7211.1 C7212.1 R7210.2 R7402.2 R7414.1 U7201.21
VDDQ_PWRGD: PG5114.1 R4011.1
VSSCORE_SENSE: CPU1.AN5 PR4666.1 R708.1
VSSGT_SENSE: CPU1.D2 PR4668.1 R808.1
VSSSA_SENSE: CPU1.BE7 PR4602.2 R809.1
0D6V_PWR: PC5116.1 PC5117.1 PG5112.2 PG5113.2 PU5102.29 PU5102.31
0D6V_S0: C1223.1 C1225.1 C1226.1 C1227.1 C1324.1 C1325.1 C1326.1 C1327.1 DM1.258 DM2.258 PG5112.1 PG5113.1
1D0V_S5: C1112.1 C1114.1 C1115.1 C1116.1 C1117.1 C1118.1 C1119.1 C1120.1 C1121.1 C1128.1 C1129.1 C2212.1 C2214.1 C2215.1 C2216.1 C2217.1 C2223.1 C4006.1 C4013.1 C4035.1 C4036.1 CPU1.BP14 CPU1.BP20 CPU1.BP22 CPU1.BR12 CPU1.BR14 CPU1.BR15 CPU1.BR20 CPU1.BT12 CPU1.BT18 CPU1.BT19 CPU1.BT22 CPU1.BU12 CPU1.BU14 CPU1.BU15 CPU1.BU18 CPU1.BU19 CPU1.BU22 CPU1.BV15 CPU1.BV16 CPU1.BV18 CPU1.BV19 CPU1.BV20 CPU1.BV22 CPU1.BW16 CPU1.BW18 CPU1.BW19 CPU1.BW20 CPU1.BW22 CPU1.BY16 CPU1.BY20 CPU1.CA12 CPU1.CA14 CPU1.CA16 CPU1.CA18 CPU1.CA19 CPU1.CA20 CPU1.CB12 CPU1.CB14 CPU1.CB15 CPU1.CC12 EC2201.1 FC8908.1 PG5201.2 PG5202.2 PG5203.2 PG5204.2 PG5205.2 PG5206.2 PG5207.2 PG5208.2 PG5209.2 PG5211.2 R2202.1 R2203.1 R2205.1 R2402.1 U4002.1 U4002.2 U4002.9 U4006.1 U4006.2 U4006.9
1D0V_VCCA_XTAL: C2219.1 C2231.1 CPU1.CP5 R2202.2
1D0V_VCCAMPHYPLL: C2208.1 C2209.1 CPU1.BV2 R2205.2
1D0V_VCCDSW: C2213.1 CPU1.BT24
1D0V_VCCPRIM_MPHY: C2220.1 CPU1.BV12 CPU1.BV14 CPU1.BW12 CPU1.BW14 CPU1.BY12 CPU1.BY14 R2203.2
1D2V_S3: C804.1 C1130.1 C1131.1 C1132.1 C1136.1 C1137.1 C1138.1 C1139.1 C1140.1 C1141.1 C1142.1 C1202.1 C1203.1 C1204.1 C1205.1 C1206.1 C1208.1 C1209.1 C1210.1 C1214.1 C1215.1 C1216.1 C1217.1 C1218.1 C1219.1 C1220.1 C1221.1 C1303.1 C1304.1 C1305.1 C1306.1 C1307.1 C1308.1 C1309.1 C1310.1 C1315.1 C1316.1 C1317.1 C1318.1 C1319.1 C1320.1 C1321.1 C1322.1 C4008.1 C4043.1 CPU1.AD36 CPU1.AH32 CPU1.AH36 CPU1.AM36 CPU1.AN32 CPU1.AW32 CPU1.AY36 CPU1.BE32 CPU1.BH36 CPU1.R32 CPU1.Y36 DM1.12 DM1.33 DM1.54 DM1.75 DM1.96 DM1.111 DM1.112 DM1.117 DM1.118 DM1.123 DM1.124 DM1.129 DM1.130 DM1.135 DM1.136 DM1.141 DM1.142 DM1.147 DM1.148 DM1.153 DM1.154 DM1.159 DM1.160 DM1.163 DM1.178 DM1.199 DM1.220 DM1.241 DM2.12 DM2.33 DM2.54 DM2.75 DM2.96 DM2.111 DM2.112 DM2.117 DM2.118 DM2.123 DM2.124 DM2.129 DM2.130 DM2.135 DM2.136 DM2.141 DM2.142 DM2.147 DM2.148 DM2.153 DM2.154 DM2.159 DM2.160 DM2.163 DM2.178 DM2.199 DM2.220 DM2.241 EC1202.1 EC1203.1 EC1303.1 EC8901.1 EC8902.1 EC8903.1 EC8904.1 EC8905.1 EC8906.1 EC8907.1 EC8908.1 EC8909.1 EC8910.1 EC8911.1 EC8912.1 EC8913.1 EC8914.1 EC8915.1 FC1102.1 FC1103.1 FC8994.1 FC8995.1 FC8996.1 FC8997.1 PG5103.2 PG5105.2 PG5106.2 PG5107.2 PG5108.2 PG5109.2 PG5110.1 PG5116.1 R505.1 R1215.1 R1312.1 RN1201.1(A) RN1301.1(A) U4003.1 U4003.2 U4003.9
1D2V_VCCSFR_OC: C803.1 C4010.1 CPU1.BL27 CPU1.BM26 U4003.6 U4003.7 U4003.8
1D05V_PWR: PC5201.1 PC5203.1 PC5205.1 PC5206.1 PC5208.1 PC5217.1 PG5201.1 PG5202.1 PG5203.1 PG5204.1 PG5205.1 PG5206.1 PG5207.1 PG5208.1 PG5209.1 PG5211.1 PG5223.2 PL5201.2
1D05V_S5_PWRGD: PU5201.1 R4029.1
1D8V_1V_VGA_S0: C7614.1 C7620.1 C7621.1 C7622.1 C7627.1 C7628.1 C7629.1 C7630.1 C7631.1 GPU1.AA10 GPU1.AA12 GPU1.AA13 GPU1.AA16 GPU1.AA18 GPU1.AA19 GPU1.AA20 GPU1.AA21 GPU1.AB22 GPU1.AC23 GPU1.AD24 GPU1.AE25 GPU1.AF26 GPU1.AF27 L7801.2 L7901.1 L7902.1 R8605.1 R8606.1
1D8V_AON_EN: Q8701.2 U8601.5 U8802.4
1D8V_AON_S0: C8004.1 C8035.1 C8036.1 C8049.1 C8625.1 C8626.1 C8805.1 C8806.1 C8808.1 GPU1.G10 GPU1.G12 PR8563.1 Q7906.G R7603.2 R7905.1 R7909.1 R7912.2 R7914.1 R7917.1 R7919.1 R7922.1 R7931.1 R7933.1 R7947.2 R7949.2 R7976.1 R7977.1 R7978.1 R8608.2 R8704.1 RN7901.3(B) RN7901.4(B) RN7910.3(B) RN7910.4(B) U7601.5 U7602.5 U8601.8 U8601.9 U8801.5 U8803.5 U8804.5
1D8V_AON_S0_DISCHG: Q8701.3 R8704.2
1D8V_AVDD2: C2710.1 HDA27.33 R2725.2
1D8V_FBA_PLL_AVDD: C7805.1 C7808.1 C7809.1 C7818.1 GPU1.F16 GPU1.H22 GPU1.P22 L7801.1
1D8V_GPU_AON_S0: C8601.1 C8627.1 R8601.2 R8602.2 U8601.1 U8601.2 U8601.6 U8601.7
1D8V_MAIN_EN: D8801.K D8803.A R7933.2 R7936.2 R7963.2 R8801.1 R8803.1 R8811.2
1D8V_MAIN_EN_D: D8803.K R8809.2
1D8V_MAIN_EN_R: C8809.1 Q8704.2 R8811.1 U8601.3
1D8V_MAIN_ENABLE: GPU1.F9 R7936.1
1D8V_S0: C4015.1 R2709.1 R2725.1 R6403.1 U4004.8 U4004.9
1D8V_S0_CT1: C4011.1 U4004.10
1D8V_S5: PG5303.2 PG5304.2 PG5305.2 R1104.2 R1515.1 R2462.2 R2491.2 R2497.2 R8602.1 U4004.6 U4004.7
1D8V_VCCPRIM: C1122.1 C2210.1 C2211.1 CPU1.CC15 CPU1.CC18 CPU1.CC19 CPU1.CD15 CPU1.CD16 CPU1.CD18 CPU1.CD19 CPU1.CP17 CPU1.CP23 R1104.1 R1512.1 R1738.1 R1821.1 R2111.1 R2113.1 R2115.1 R2117.1 RN2001.1(A) RN2001.2(A)
1D8V_VGA_DISC: Q8704.5 Q8704.6 R8708.1
1D8V_VGA_PLL: C7905.1 C7906.1 GPU1.L6 L7901.2 R8003.1
1D8V_VGA_S0: C8003.1 C8028.1 C8029.1 C8034.1 C8050.1 C8603.1 GPU1.G8 GPU1.G9 Q7601.G Q7901.2 Q7901.5 R7946.2 R8605.2 R8607.2 R8707.1 R8810.1 U8601.13 U8601.14
1D8V_VGA_S0_DISCHG: Q8704.3 R8707.2
1D24V_VCCDPHY: CPU1.BY23 CPU1.BY24 CPU1.CA23 CPU1.CA24
1D24V_VCCDPHY_EC: C2218.1 CPU1.CP25
1D35V_PGOOD: PR8630.1 U7302.2 U8802.2
1D35V_PWR: PC8611.1 PC8613.1 PC8614.1 PC8620.1 PC8621.1 PG8609.1 PG8610.1 PG8611.1 PG8612.1 PG8613.1 PG8618.1 PG8619.1 PG8620.1 PG8621.1 PL8603.2
1D35V_VGA_EN#: Q8702.5 Q8702.6 R8705.1
1D35V_VGA_S0: C7801.1 C7802.1 C7807.1 C7810.1 C7811.1 C7812.1 C7813.1 C7814.1 C7817.1 C7819.1 C7820.1 C7821.1 C7822.1 C7823.1 C7824.1 C7825.1 C7826.1 C7827.1 C7828.1 C7829.1 C8101.1 C8102.1 C8103.1 C8104.1 C8105.1 C8106.1 C8107.1 C8108.1 C8109.1 C8110.1 C8111.1 C8112.1 C8113.1 C8114.1 C8115.1 C8116.1 C8117.1 C8118.1 C8119.1 C8120.1 C8121.1 C8122.1 C8123.1 C8124.1 C8125.1 C8126.1 C8127.1 C8128.1 C8129.1 C8130.1 C8131.1 C8132.1 C8143.1 C8144.1 C8145.1 C8146.1 GPU1.B26 GPU1.C25 GPU1.E23 GPU1.E26 GPU1.F14 GPU1.F21 GPU1.G13 GPU1.G14 GPU1.G15 GPU1.G16 GPU1.G18 GPU1.G19 GPU1.G20 GPU1.G21 GPU1.H24 GPU1.H26 GPU1.J21 GPU1.K21 GPU1.L22 GPU1.L24 GPU1.L26 GPU1.M21 GPU1.N21 GPU1.R21 GPU1.T21 GPU1.V21 GPU1.W21 PG8609.2 PG8610.2 PG8611.2 PG8612.2 PG8618.2 PG8619.2 PG8620.2 PG8621.2 R7803.2 R7804.2 R7805.2 R7816.2 R7824.2 R8101.1 R8104.1 R8111.2 R8709.1 VRAM1.B1 VRAM1.B3 VRAM1.B12 VRAM1.B14 VRAM1.C5 VRAM1.C10 VRAM1.D1 VRAM1.D3 VRAM1.D11 VRAM1.D12 VRAM1.D14 VRAM1.E5 VRAM1.E10 VRAM1.F1 VRAM1.F3 VRAM1.F12 VRAM1.F14 VRAM1.G1 VRAM1.G2 VRAM1.G4 VRAM1.G11 VRAM1.G13 VRAM1.G14 VRAM1.H3 VRAM1.H12 VRAM1.K3 VRAM1.K12 VRAM1.L1 VRAM1.L2 VRAM1.L4 VRAM1.L11 VRAM1.L13 VRAM1.L14 VRAM1.M1 VRAM1.M3 VRAM1.M12 VRAM1.M14 VRAM1.N5 VRAM1.N10 VRAM1.P1 VRAM1.P3 VRAM1.P11 VRAM1.P12 VRAM1.P14 VRAM1.R5 VRAM1.R10 VRAM1.T1 VRAM1.T3 VRAM1.T12 VRAM1.T14 VRAM4.B1 VRAM4.B3 VRAM4.B12 VRAM4.B14 VRAM4.C5 VRAM4.C10 VRAM4.D1 VRAM4.D3 VRAM4.D11 VRAM4.D12 VRAM4.D14 VRAM4.E5 VRAM4.E10 VRAM4.F1 VRAM4.F3 VRAM4.F12 VRAM4.F14 VRAM4.G1 VRAM4.G2 VRAM4.G4 VRAM4.G11 VRAM4.G13 VRAM4.G14 VRAM4.H3 VRAM4.H12 VRAM4.K3 VRAM4.K12 VRAM4.L1 VRAM4.L2 VRAM4.L4 VRAM4.L11 VRAM4.L13 VRAM4.L14 VRAM4.M1 VRAM4.M3 VRAM4.M12 VRAM4.M14 VRAM4.N5 VRAM4.N10 VRAM4.P1 VRAM4.P3 VRAM4.P11 VRAM4.P12 VRAM4.P14 VRAM4.R5 VRAM4.R10 VRAM4.T1 VRAM4.T3 VRAM4.T12 VRAM4.T14
1D35V_VGA_S0_DISCHG: Q8702.3 R8709.2
2D5V_S3: C1207.1 C1231.1 C1311.1 C1313.1 DM1.257 DM1.259 DM2.257 DM2.259 PR5121.1 PR5122.1
3D3V_AON_1D8V_VGA_S0: C7616.1 GPU1.AA8 GPU1.AA9 R7616.2 R8607.1 R8608.1
3D3V_AUX_S5: AFTP6402.1 C6401.2 PG4532.2 PR4505.1 PWR1.1 R1726.2 R1737.1 R2463.1 R2505.1 R7952.2
3D3V_CAMERA: F5504.1 R5501.2 U5503.13 U5503.14
3D3V_CAMERA_CT1: C5539.1 U5503.12
3D3V_CAMERA_S0: AFTP5511.1 C5503.1 F5504.2 FC8919.1 LCD1.23
3D3V_GSEN2: C7003.1 C7004.1 R7004.2 R7006.2 U7001.9 U7001.10
3D3V_LAN_CT2: C4017.1 U4001.10
3D3V_LAN_S5: C3103.1 C3110.1 C3117.1 C3121.1 C3124.1 C4014.1 LED2.A R3103.2 R4047.2 U3101.11 U3101.23 U3101.32
3D3V_LAN_S5_R: R4047.1 U4001.8 U4001.9
3D3V_LCDVDD_S0: AFTP5523.1 C5530.1 C5536.1 C5538.1 C5541.1 C5599.1 D5505.A FC8964.1 LCD1.35 LCD1.36 LCD1.37 U5501.1
3D3V_MUX: C7115.2 C7116.2 C7117.2 C7118.2 C7119.1 L7101.2 R7101.1 R7140.1 R7142.1 R7145.1 R7147.1 R7152.1 R7171.1 R7174.1 R7175.1 R7189.1 R7190.1 U7101.6 U7101.20 U7101.28
3D3V_MUX2: C7120.1 R7126.2 U7102.13
3D3V_MUX_VCC: C7165.2 R7175.2 U7101.1
3D3V_RTC: C2503.1 D2501.3 Q2507.S R2472.2 R2708.1
3D3V_RTC_AUX_S5: Q2507.D R1730.1 R2204.1 R2476.2 R2506.2 RN1801.1(A) RN1801.2(A)
3D3V_RTC_SYS: D2501.1 R2505.2 R2517.1
3D3V_S0: AFTP6611.1 C1228.1 C1328.1 C1329.1 C2432.1 C2601.1 C2602.1 C4004.1 C5809.2 C5810.2 C5811.1 C5812.1 C5813.1 C8807.1 C9104.1 DBG1.10 DM1.255 DM2.255 EC8950.1 EC8951.1 EC8952.1 EC8953.1 EC8959.1 EC8960.1 EC8975.1 EC8977.1 EC8978.1 EC8979.1 EC8980.1 EC8991.1 EC8992.1 EC8993.1 EC8994.1 EC8995.1 EC8996.1 EC8997.1 EC8998.1 EC8999.1 EC9001.1 FC8901.1 FC8907.1 FC8970.1 FC8984.1 FC8998.1 IOBD1.14 IOBD1.15 PG8605.1 PR4609.1 PR8530.1 PR8611.1 PR8634.2 Q1801.2 Q1801.5 Q2414.G Q2601.2 Q2601.5 Q5702.2 Q5702.5 Q5703.C Q5801.2 Q5801.5 Q6504.2 Q6504.5 R407.2 R507.1 R1204.2 R1208.2 R1211.2 R1216.1 R1302.2 R1306.2 R1310.2 R1606.1 R1617.1 R1820.1 R1822.1 R1823.1 R1824.1 R1825.1 R1826.1 R1827.1 R2008.1 R2010.1 R2043.1 R2044.1 R2045.1 R2046.1 R2048.1 R2049.1 R2053.1 R2059.1 R2064.1 R2065.1 R2066.1 R2430.2 R2467.2 R2489.2 R2603.1 R2604.1 R2617.1 R2618.1 R2715.1 R3109.1 R4005.1 R4010.1 R5501.1 R5517.1 R5518.1 R5550.2 R5556.2 R5557.1 R5564.2 R5805.1 R5807.1 R5809.1 R5811.1 R5813.1 R5815.1 R5817.1 R5820.1 R5821.1 R5822.1 R5834.1 R6124.2 R6302.1 R6348.1 R6349.1 R6411.1 R6415.1 R6502.1 R7004.1 R7010.1 R7948.2 R7953.1 R8701.2 R8703.2 R8705.2 R8708.2 R8710.2 R8806.1 R9150.1 R9211.2 RN401.1(A) RN401.2(A) RN401.3(A) RN401.4(A) RN1810.1(A) RN1810.2(A) RN2601.1(A) RN2601.2(A) U2402.5 U2601.1 U4001.13 U4001.14 U5503.1 U5503.2 U5802.5 U5802.21 U5802.30 U5802.51 U5802.57 U7302.5 U8802.5 U9103.8 VGABD1.3 VGABD1.4
3D3V_S5: C2416.1 C2421.1 C5505.1 C6102.1 C6502.1 C9106.1 C9108.1 D4302.2 D7202.A EC8940.1 EC8941.1 EC8942.1 EC8943.1 EC8944.1 EC8945.1 EC8946.1 FC8911.1 FC8966.1 FC8967.1 L7101.1 PC4509.1 PC4510.1 PC4511.1 PC4512.1 PC4513.1 PC4525.1 PC5124.1 PG4530.2 PG5301.1 PG5302.1 PL4501.2 PR4431.1 PR4432.2 PR4435.1 PR4450.2 PR4472.1 PR5101.1 PR5112.1 PR5306.1 PU5101.5 PU5101.9 Q2416.2 Q2416.5 Q6502.S Q9201.S R506.1 R1721.1 R1739.2 R1910.1 R2434.1 R2442.1 R2446.1 R2492.1 R2495.1 R2498.1 R2499.1 R2514.1 R2520.1 R2607.1 R4031.1 R4048.1 R4304.1 R4378.1 R5547.2 R6102.1 R6125.1 R6404.2 R6611.1 R7126.1 R7216.1 R7424.1 R7427.1 R8601.1 R9149.1 R9212.1 RN2405.3(B) RN2405.4(B) U2502.5 U4001.1 U4001.2 U4001.6 U4001.7 U4007.5 U4302.2 U5501.5 U6101.5 U9103.1 WWAN1.1 WWAN1.2 WWAN1.3 WWAN1.4 WWAN1.5
3D3V_S5_PCH: FC8999.1 R405.1 R406.1 R1103.1 R1502.1 R1504.1 R1506.1 R1508.1 R1510.1 R1513.1 R1522.1 R1551.1 R1554.1 R1837.1 R2041.1 R2047.1 R2055.1 R2060.1 R2061.1 R2062.1 R2068.1 R2119.1 R2515.1 R2516.2 R2519.1 R2521.1 R6609.1 R6877.2 R9148.1 RN1601.1(A) RN1601.2(A) RN1601.3(A) RN1601.4(A) RN1807.1(A) RN1807.2(A) RN1807.3(A) RN1807.4(A) RN1811.1(A) RN1811.2(A)
3D3V_S5_PCH_R: Q401.2 Q401.3 R406.2
3D3V_SPIVCC1: BIOS1.8 BIOS2.8 C2501.1 C2502.1 R2515.2
3D3V_SSD: C6304.1 C6305.1 C6306.1 C6307.1 C6308.1 C6317.1 C6318.1 FC8962.1 R6302.2 R6349.2 SSD1.2 SSD1.4 SSD1.12 SSD1.14 SSD1.16 SSD1.18 SSD1.70 SSD1.72 SSD1.74
3D3V_TP_CT2: C5540.1 U5503.10
3D3V_TPM: C9109.1 C9112.1 C9113.1 R9119.2 R9149.2 R9150.2 U9103.22
3D3V_VCCDSW: C2224.1 C2230.1 CPU1.BR24 CPU1.BT23 R1520.1 R1524.1 R1707.1 R2516.1 RN1704.1(A) RN1704.2(A) RN1704.3(A) RN1704.4(A) U2502.1
3D3V_VCCPRIM: C1113.1 C1123.1 C2202.1 C2203.1 C2204.1 C2205.1 C2206.1 C2207.1 C2225.1 C2226.1 C2227.1 C2228.1 CPU1.BP23 CPU1.BT20 CPU1.BV23 CPU1.BW23 CPU1.CB16 CPU1.CB22 CPU1.CB23 CPU1.CC22 CPU1.CC23 CPU1.CD22 CPU1.CD23 CPU1.CP29 R1103.2 R1701.1 R1731.1
3D3V_VCCPRTC: C2221.1 C2222.1 C2229.1 CPU1.BR23 R2204.2
3D3V_WLAN: AFTP6113.1 C6104.1 C6105.1 C6106.1 FC9005.1 FC9006.1 R6114.1 R6115.1 R6124.1 R6125.2 U6101.1 WLAN1.2 WLAN1.4 WLAN1.72 WLAN1.74
27MHZ_IN: C7907.2 GPU1.C11 R7903.1 X7901.1
27MHZ_OUT: GPU1.B10 R7903.2 R7904.2
27MHZ_OUT_R: C7908.2 R7904.1 X7901.3
+DC_IN: C4301.1 C4302.1 EL4301.2 EL4302.2 PU4301.1 PU4301.2 PU4301.3 Q4305.2 R4307.1 R4376.1
+DC_IN_C: AFTP4303.1 D4301.K DCIN1.6 DCIN1.7 DCIN1.8 EC4301.1 EC4302.1 EC4312.1 EC4313.1 EL4301.1 EL4302.1
+RTC_CELL_VBAT: C2428.1 R2451.2 R2472.1 R2476.1 R2496.2 U2401.122
+RTC_VCC: AFTP6615.1 D2501.2 IOBD1.13 Q2505.G R2504.1
+SDC_IN: C4444.1 C7401.1 EC8969.1 EC8971.1 EC8972.1 EC8973.1 EC8974.1 EC8976.1 PG4401.1 PR4401.1 PR4434.2 PU4302.1 PU4302.2 PU4302.3 Q4448.S Q7401.S R4464.1 R4468.1 R7406.1 R7407.2 R7432.1 U7418.1 U7418.2 U7418.3
+SDC_IN_SW: C4444.2 PU4302.4 R4464.2 R4465.2 R4466.1
+SDC_IN_SW_R1: Q4449.3 R4465.1
+V_VREF_PATH1: C1222.2 R1209.1
+V_VREF_PATH2: C1323.2 R1309.1
AC_DIS: Q4304.B R4312.1 R4481.2 U2401.69
AC_IN#_G: R4376.2 R4377.1 U4302.5
AC_PRESENT: CPU1.BU35 D1701.A EC1707.1 Q1702.3 RN1704.7(B)
ACOK#: PQ4415.2 PQ4415.3 PR4427.2
ACOK_IN_M: D1701.K D4305.K PQ4415.6
AD_IA: PC4432.1 PR4412.1 R2421.1
AD_OFF_L: Q4304.C Q4305.1
AD_OFF_R: C4301.2 PU4301.4 Q4305.3 R4307.2 R4308.1
ALERT#: R2603.2 U2601.6
ALWON: R4009.2 U2401.121
AMBER_LED_BAT: EC6402.1 Q6403.C R6407.1
AON_CT_2: C8605.1 U8601.10
AUD_AGND: C2702.1 C2703.2 C2706.2 C2707.2 C2710.2 C2711.2 C2715.2 C2902.2 EC2701.1 EC2702.1 EC2703.1 EC2704.1 EC2705.1 EC2905.2 EC2906.2 EC2907.2 EC2908.2 HDA27.19 HDA27.31 HPMIC1.MS R2702.2 R2704.1 R2705.1 R2914.2
AUD_HP1_JACK_L: HDA27.25 R2908.1 R2913.2 R2922.2
AUD_HP1_JACK_L1: EC2907.1 R2907.1 R2908.2
AUD_HP1_JACK_R: HDA27.26 R2910.1 R2912.2 R2921.2
AUD_HP1_JACK_R1: EC2908.1 R2909.1 R2910.2
AUD_HPJD_N: HDA27.12 R2710.2 R2711.2
AUD_PC_BEEP: C2735.2 HDA27.11
AUD_PC_BEEP_C: C2735.1 D2703.3 R2735.1
AUD_PORTA_L_HPMIC1: ED2910.1 HPMIC1.1 R2907.2
AUD_PORTA_R_HPMIC1: ED2910.2 HPMIC1.2 R2909.2
AUD_RING: EC2905.1 HDA27.13 R2906.1 RN2901.4(B)
AUD_SENSE: C2902.1 R2711.1 R2923.2
AUD_SLEEVE: EC2906.1 HDA27.14 R2911.1 RN2901.3(B)
AUD_SPK_L+: EC2904.1 HDA27.35 R2926.1
AUD_SPK_L+_C: AFTP2902.1 R2926.2 SPK1.3
AUD_SPK_L-: EC2903.1 HDA27.36 R2927.1
AUD_SPK_L-_C: AFTP2901.1 R2927.2 SPK1.4
AUD_SPK_R+: EC2902.1 HDA27.38 R2924.1
AUD_SPK_R+_C: AFTP2904.1 R2924.2 SPK1.1
AUD_SPK_R-: EC2901.1 HDA27.37 R2925.1
AUD_SPK_R-_C: AFTP2903.1 R2925.2 SPK1.2
AUD_VREF: C2702.2 HDA27.22
AUX_EN_WOWL: CPU1.BT30 R1718.2
AUX_EN_WOWL_R: Q6102.S R1718.1 R2409.2
AUX_ON: R2466.2 U2401.3
BAT1_LED#: Q2416.4 R2452.1 RN2405.1(A) U2401.106
BAT2_LED#: Q2416.1 R2453.2 RN2405.2(A) U2401.1
BAT_AMBER: LED1.1 R6407.2
BAT_WHITE: LED1.2 R6406.2
BATT_WHITE_LED#: Q2416.6 Q6401.D Q6406.4 R2453.1 R6409.2
BATT_WHITE_LED#_Q: Q6404.B Q6406.3 R6409.1
