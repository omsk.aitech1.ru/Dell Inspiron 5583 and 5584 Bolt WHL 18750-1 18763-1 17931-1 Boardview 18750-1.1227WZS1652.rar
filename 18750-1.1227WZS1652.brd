# Allegro board 18750-1.1227WZS1652.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_D55: length 34.9
  L3 w0.089: 164.39,145.9 164.39,146.94 v1(164,147.33)
  L3 w0.114: v1(135.94,141.95) 135.94,141.94 136.1,141.94 139.47,145.31 146.01,145.31 148.04,143.28 151.36,143.28 151.69,143.61 162.73,143.61 164.39,145.26 164.39,145.9
  BOTTOM w0.14: VRAM4.E11 v1(164,147.33) ; GPU1.Y25 136.47,141.95 v1(135.94,141.95)
FBA_D56: length 38.2
  L3 w0.114: v1(141.05,139.34) 141.31,139.08 144.48,139.08 150.33,133.23 164.8,133.23 168.02,136.45 168.02,140.92 v1(167.2,141.75)
  BOTTOM w0.14: VRAM4.A4 167.2,141.73 v1(167.2,141.75) ; GPU1.R26 140.82,139.57 v1(141.05,139.34)
FBA_D57: length 35.9
  L3 w0.114: v1(167.24,139.29) 167.67,138.86 167.67,137.39 167.57,137.29 167.57,136.87 164.38,133.68 150.52,133.68 144.58,139.63 141.77,139.63 141.64,139.75 141.33,139.75 140.39,139.75 140.23,139.59 v1(139.42,139.59)
  BOTTOM w0.14: v1(139.42,139.59) 138.87,139.59 GPU1.T25 ; VRAM4.A2 v1(167.24,139.29)
FBA_D58: length 35.3
  L3 w0.114: v1(142.79,141.61) 143.04,141.35 144.15,141.35 150.9,134.6 163.6,134.6 166.52,137.52 166.52,140.01 v1(165.6,140.93)
  BOTTOM w0.14: GPU1.N27 141.73,139.84 142.79,140.89 v1(142.79,141.61) ; VRAM4.B4 v1(165.6,140.93)
FBA_D59: length 35.5
  L3 w0.089: 166.8,139.49 166.8,139.67 v1(167.24,140.11)
  L3 w0.114: v1(141.91,140.66) 142.36,140.21 144.64,140.21 150.71,134.14 163.89,134.14 167.39,137.64 167.39,138.51 166.8,139.1 166.8,139.49 166.8,139.49
  BOTTOM w0.14: GPU1.R27 141.07,140.66 v1(141.91,140.66) ; v1(167.24,140.11) 166.38,140.11 VRAM4.B2
FBA_D60: length 31.2
  L3 w0.114: v1(163.22,139.35) 163.31,139.26 163.31,137.95 162.27,136.91 151.2,136.91 144.9,143.21 141.65,143.21 141.45,143 v1(140.82,143)
  BOTTOM w0.14: VRAM4.E2 v1(163.22,139.35) ; v1(140.82,143) 139.99,143 139.34,142.36 138.71,142.36 138.32,141.96 138.32,141.42 138.23,141.32
FBA_D61: length 32.7
  L3 w0.089: 164.35,138.98 164.38,139.01 164.38,139.94 164.4,139.96 164.4,140.51 164,140.91 v1(164,140.93)
  L3 w0.114: v1(139.88,142.07) 141.16,142.07 141.84,142.75 144.71,142.75 151.01,136.45 162.5,136.45 163.85,137.8 163.85,138.48 164.35,138.98
  BOTTOM w0.14: GPU1.V27 138.98,142.07 v1(139.88,142.07) ; VRAM4.E4 164,140.93 v1(164,140.93)
FBA_D62: length 29.5
  L3 w0.089: 162.49,138.21 162.49,139.24 v1(162.4,139.33)
  L3 w0.114: 162.49,138.21 161.64,137.36 151.39,137.36 145.08,143.68 140.73,143.68 139.9,142.85 v1(139.13,142.85)
  BOTTOM w0.14: GPU1.W27 138.66,142.88 v1(139.13,142.85) ; VRAM4.F2 v1(162.4,139.33)
FBA_D63: length 33.2
  L3 w0.089: v1(162.4,140.93) 162.4,140.82 162,140.42 162,139.82 161.67,139.5 161.67,138.1 161.55,137.97
  L3 w0.114: v1(140.49,144.2) 145.21,144.2 151.56,137.85 161.42,137.85 161.55,137.97
  BOTTOM w0.14: GPU1.W25 137.69,141.32 138.04,141.67 138.04,142.12 137.76,142.39 137.76,142.73 138.3,143.26 138.91,143.26 139.85,144.2 v1(140.49,144.2) ; VRAM4.F4 v1(162.4,140.93)
FBA_DEBUG0: length 20.1
  TOP w0.089: v1(144.09,131.37) 144.15,131.32 144.15,129.58 144.94,128.78 144.94,127.02 146.11,125.85 146.11,125.84 146.34,125.61 146.35,125.61 146.56,125.4 146.56,119.94 148.8,117.7 150.32,117.7 R7803.1 150.65,116.94 v2(151.08,116.5)
  BOTTOM w0.089: GPU1.F22 142.94,132.01 143.46,132.01 v1(144.09,131.37)
FBA_DEBUG1: length 21.6
  TOP w0.089: v1(141.79,133.8) 141.99,133.6 141.99,133.02 142.5,132.51 142.5,131.24 143.39,130.35 143.39,129.21 144.08,128.51 144.48,128.51 144.64,128.36 144.64,126.95 146.18,125.4 146.18,119.81 148.85,117.15 R7804.1 149.56,117.15 v2(149.89,116.81)
  BOTTOM w0.089: v1(141.79,133.8) 141.79,133.8 141.76,133.77 GPU1.J22
FBA_DQM0: length 15.5
  L6 w0.089: v1(143.52,128.49) 143.68,128.34 144.31,128.34 145.11,127.53 ; v1(156,126.63) 156,126.63 155.61,126.24 155.37,126.24 155.37,126.23 154.56,126.23 154.56,126.23 153.77,126.23 153.77,126.23 152.61,126.23 152.6,126.21
  L6 w0.114: 152.6,126.21 147.53,126.21 146.59,127.15 145.49,127.15 145.11,127.53
  BOTTOM w0.14: VRAM1.D2 156,126.63 v1(156,126.63) ; GPU1.D19 142.99,129.02 v1(143.52,128.49)
FBA_DQM1: length 23.7
  L6 w0.089: v1(156,117.83) 155.6,117.43 155.6,116.61 155.37,116.38 ; 141.86,122.97 140.26,124.57 139.82,124.57 138.88,125.51 v1(138.88,126.09)
  L6 w0.114: 141.86,122.97 142.15,122.68 142.47,122.68 147.25,117.91 151.94,117.91 153.47,116.38 155.37,116.38
  BOTTOM w0.14: v1(138.88,126.09) 138.89,126.11 GPU1.D14 ; VRAM1.D13 v1(156,117.83)
FBA_DQM2: length 30.9
  L3 w0.114: v1(141.19,127.29) 141.19,126.7 142.18,125.71 142.87,125.71 150.32,118.26 151.78,118.26 153.65,116.4 164.54,116.4 164.67,116.52 164.67,117.7 v1(164.8,117.83)
  BOTTOM w0.14: GPU1.C17 v1(141.19,127.29) ; VRAM1.P13 v1(164.8,117.83)
FBA_DQM3: length 23.9
  L3 w0.089: v1(163.99,126.62) 164.38,127.02 164.38,127.81 164.06,128.13 164.06,129.09
  L3 w0.114: v1(146.38,129.65) 147.15,128.88 149.91,128.88 150.75,129.72 163.44,129.72 164.06,129.09
  BOTTOM w0.14: GPU1.C22 145.26,130.21 145.68,129.79 146.24,129.79 v1(146.38,129.65) ; VRAM1.P2 164.39,127.03 v1(163.99,126.62)
FBA_DQM4: length 19.1
  L6 w0.089: v1(139.99,137.86) 140.1,137.97 140.73,137.97 141.67,138.91 ; 154.9,137.7 155.14,137.94 155.14,138.48 155.43,138.77 155.44,138.77 v1(156,139.33)
  L6 w0.114: 141.67,138.91 144.35,138.91 144.67,138.59 152.78,138.59 152.9,138.47 152.9,138.42 153.62,137.7 154.9,137.7
  BOTTOM w0.14: v1(139.99,137.86) 139.98,137.84 GPU1.P24 ; VRAM4.P2 v1(156,139.33)
FBA_DQM5: length 25.9
  L6 w0.089: 153.09,148.54 153.11,148.53 155.03,148.53 155.03,148.53 155.36,148.53 155.36,148.53 155.64,148.53 v1(156.02,148.91)
  L6 w0.114: 153.09,148.54 149.08,148.54 148.76,148.22 148.76,148.06 148.99,147.83 148.99,147.66 148.83,147.5 148.66,147.5 148.43,147.74 148.27,147.74 148.11,147.57 148.11,147.41 148.34,147.18 148.34,147.02 148.18,146.86 148.02,146.86 147.79,147.09 147.62,147.09 146.69,146.15 140.66,146.15 136.66,142.14 136.66,141.48 v1(136.52,141.34)
  BOTTOM w0.14: GPU1.W24 136.53,141.31 136.52,141.32 v1(136.52,141.34) ; VRAM4.P13 v1(156.02,148.91)
FBA_DQM6: length 36.5
  L3 w0.114: v1(137.66,144.26) 136.92,145 136.92,145.66 138.86,147.6 141.07,147.6 144.67,151.2 149.82,151.2 150.6,150.42 160.79,150.42 161.04,150.17 164.16,150.17 164.57,149.76 164.57,149.16 v1(164.78,148.95)
  BOTTOM w0.14: v1(137.66,144.26) 137.66,143.66 136.52,142.51 GPU1.AA25 ; VRAM4.D13 164.78,148.91 v1(164.78,148.95)
FBA_DQM7: length 33.5
  L3 w0.089: v1(164.8,139.33) 164.86,139.27 164.86,138.09
  L3 w0.114: 164.86,138.09 164.86,137.71 162.66,135.51 151.3,135.51 144.52,142.29 142.09,142.29 v1(141.87,142.07)
  BOTTOM w0.14: GPU1.U25 138.77,140.16 139.22,140.61 139.22,140.83 139.92,141.53 140.18,141.53 140.72,142.07 v1(141.87,142.07) ; VRAM4.D2 v1(164.8,139.33)
FBA_EDC0: length 16.8
  L6 w0.089: v1(141.81,130.18) 142.36,130.18 142.82,130.64 143.1,130.64 143.49,130.25 144.9,130.25 146.12,129.03 147.24,129.03 147.45,128.82 148.58,128.82
  L6 w0.114: 148.58,128.82 149.07,128.82 149.17,128.92 154.78,128.92 155.12,128.59 155.12,127.51 v1(155.2,127.43)
  BOTTOM w0.14: v1(141.81,130.18) 141.81,129.6 GPU1.E19 ; VRAM1.C2 v1(155.2,127.43)
FBA_EDC1: length 19.7
  L6 w0.089: 140.8,125.34 v1(140,126.14)
  L6 w0.114: v1(155.2,118.63) 154.91,118.34 152.83,118.34 152.17,119 147.68,119 141.34,125.34 140.8,125.34
  BOTTOM w0.14: v1(140,126.14) 140.6,126.14 GPU1.C15 ; VRAM1.C13 v1(155.2,118.63)
FBA_EDC2: length 31.5
  L3 w0.114: v1(142.68,125.1) 143.18,125.1 144.28,124 144.28,123.52 149.99,117.81 151.48,117.81 151.74,117.54 153.28,116 165.01,116 165.51,116.5 165.51,118.54 v1(165.6,118.63)
  BOTTOM w0.14: v1(142.68,125.1) 142.23,125.1 141.73,125.59 141.73,126.14 ; VRAM1.R13 v1(165.6,118.63)
FBA_EDC3: length 23.3
  L3 w0.114: v1(147.04,129.64) 147.59,129.1 149.47,129.1 150.55,130.17 163.63,130.17 164.88,128.92 164.88,127.51 v1(164.8,127.43)
  BOTTOM w0.14: GPU1.B22 145.39,129.49 145.93,129.49 146.19,129.23 146.63,129.23 v1(147.04,129.64) ; v1(164.8,127.43) 165.2,127.03 VRAM1.R2
FBA_EDC4: length 16.8
  L6 w0.089: 152.85,139.75 152.87,139.73 153.77,139.73 154.8,139.73 v1(155.2,140.13)
  L6 w0.114: v1(139.99,138.99) 140.75,139.75 152.85,139.75
  BOTTOM w0.14: GPU1.R25 139.43,138.99 v1(139.99,138.99) ; VRAM4.R2 v1(155.2,140.13)
FBA_EDC5: length 32.3
  L6 w0.089: v1(136.53,140.2) 136.73,140.4 136.73,140.89 137.54,141.7 137.54,141.94 ; 153.36,147.71 154.78,147.71 v1(155.2,148.13)
  L6 w0.114: 153.36,147.71 153.22,147.71 152.91,147.4 152.78,147.4 152.66,147.51 152.66,147.97 152.55,148.08 152.32,148.08 152.21,147.97 152.21,147.51 152.09,147.4 151.86,147.4 151.75,147.51 151.75,147.97 151.64,148.08 151.41,148.08 151.29,147.97 151.29,147.51 151.18,147.4 150.95,147.4 150.84,147.51 150.84,147.97 150.72,148.08 150.49,148.08 150.38,147.97 150.38,147.51 150.26,147.4 149.38,147.4 148.07,146.08 147.91,146.08 147.67,146.32 147.51,146.32 147.35,146.15 147.35,145.99 147.58,145.76 147.58,145.6 147.25,145.26 147.01,145.26 146.89,145.38 146.89,145.58 146.78,145.7 146.55,145.7 146.43,145.58 146.43,145.38 146.32,145.26 146.09,145.26 145.98,145.38 145.98,145.58 145.86,145.7 145.63,145.7 145.52,145.58 145.52,145.38 145.41,145.26 145.18,145.26 145.06,145.38 145.06,145.58 144.95,145.7 144.72,145.7 144.61,145.58 144.61,145.38 144.49,145.26 144.26,145.26 144.15,145.38 144.15,145.58 144.03,145.7 143.81,145.7 143.69,145.58 143.69,145.38 143.58,145.26 143.35,145.26 143.23,145.38 143.23,145.58 143.12,145.7 142.89,145.7 142.78,145.58 142.78,145.38 142.66,145.26 142.43,145.26 142.32,145.38 142.32,145.58 142.2,145.7 141.98,145.7 141.86,145.58 141.86,145.38 141.75,145.26 141.52,145.26 141.4,145.38 141.4,145.58 141.29,145.7 141.06,145.7 140.95,145.58 140.95,145.38 140.83,145.26 140.08,145.26 137.54,142.73 137.54,141.94
  BOTTOM w0.14: VRAM4.R13 v1(155.2,148.13) ; v1(136.53,140.2) 135.97,140.2 GPU1.W23
FBA_EDC6: length 37.2
  L3 w0.089: v1(165.6,148.13) 165.18,148.55 165.18,149.2
  L3 w0.114: 165.18,149.2 164.95,149.43 164.95,149.96 164.46,150.45 161.39,150.45 160.96,150.88 150.85,150.88 150.18,151.55 150.16,151.55 150.02,151.69 144.35,151.69 140.85,148.19 138.76,148.19 137.32,146.75 v1(136.72,146.75)
  BOTTOM w0.14: GPU1.AB26 135.74,143.81 135.74,144.51 136.46,145.24 136.46,145.74 136.72,146 v1(136.72,146.75) ; VRAM4.C13 v1(165.6,148.13)
FBA_EDC7: length 33.7
  L3 w0.089: v1(165.6,139.33) 165.71,139.22 165.71,138.05
  L3 w0.114: 165.71,138.05 165.71,137.53 163.24,135.06 151.11,135.06 144.36,141.81 143.46,141.81 143.23,142.04 142.5,142.04 141.63,141.18 141.55,141.18 v1(140.95,141.18)
  BOTTOM w0.14: v1(140.95,141.18) 139.91,141.18 139.56,140.82 139.56,140.28 GPU1.T26 ; VRAM4.C2 v1(165.6,139.33)
FBA_MF0: length 1.9
  TOP w0.152: v2(160.1,127.79) v1(160.22,128.34) 160.28,128.39 R8112.2
  BOTTOM w0.152: v1(160.22,128.34) 160.22,128.01 VRAM1.J1
FBA_MF1: length 1.9
  TOP w0.089: v2(160.8,138.75) v1(160.4,138.36) 160.4,137.62 R8111.1
  BOTTOM w0.089: v1(160.4,138.36) VRAM4.J1
FBA_SEN0: length 8.8
  L6 w0.254: v1(160.4,121.16) 160.01,120.78 154.58,120.78 v1(154.05,121.3)
  BOTTOM w0.254: v1(154.05,121.3) 154.02,121.3 153.55,120.83 R8109.2 ; VRAM1.J10 v1(160.4,121.16)
FBA_SEN1: length 9.4
  BOTTOM w0.152: VRAM4.J10 159.42,145.15 153.61,145.15 152.91,145.85 v2(152.76,145.85) R8110.2
FBA_VREF_FET_L: length 5.1
  BOTTOM w0.508: R8102.1 162.11,114.2 Q8101.D 162.85,113.34 163.16,113.03 164.57,113.03 v2(164.6,113.06) 164.65,113.01 R8105.1
FBA_WCK01: length 20.6
  L6 w0.102: v1(141.77,127.88) 141.89,127.76 142.94,127.76 144.2,126.5 144.75,126.5 147.62,123.62 153.39,123.62 153.65,123.37 153.65,122.41 153.77,122.29 154.06,122.29 154.2,122.43 154.2,123.29 154.47,123.56 155.75,123.56 156.05,123.86 156.05,124.87 155.99,125.02 v1(156,125.03)
  BOTTOM w0.114: v1(141.77,127.88) 141.77,128.43 GPU1.D18
  BOTTOM w0.14: VRAM1.D4 v1(156,125.03)
FBA_WCK01#: length 20.6
  L6 w0.102: v1(142.36,127.32) 142.6,127.56 142.86,127.56 144.12,126.3 144.66,126.3 147.54,123.42 153.31,123.42 153.45,123.28 153.45,122.33 153.69,122.09 154.14,122.09 154.4,122.34 154.4,123.21 154.55,123.36 155.83,123.36 156.25,123.78 156.25,124.5 156.79,125.03 v1(156.8,125.03)
  BOTTOM w0.114: v1(142.36,127.32) GPU1.C18
  BOTTOM w0.14: VRAM1.D5 v1(156.8,125.03)
FBA_WCK23: length 28.5
  L3 w0.102: v1(164,125.03) 163.86,124.89 163.86,124.66 163.93,124.59 164.54,124.59 164.6,124.53 164.6,124.31 164.48,124.19 163.08,123.63 154.65,123.63 153.92,123.87 153.2,124.1 151.94,125.37 147.49,126.6 146.25,127.15 145.16,127.15 143.9,127.5 142.98,128.42 142.98,128.71 142.63,129.06 142.09,129.06 141.83,128.8 141.56,128.8 141.46,128.9 141.28,128.9 141.15,128.78 141.15,128.58 v1(141.2,128.46)
  BOTTOM w0.114: GPU1.D17 v1(141.2,128.46)
  BOTTOM w0.14: v1(164,125.03) VRAM1.P4
FBA_WCK23#: length 28.5
  L3 w0.102: v1(164.8,125.03) 164.8,124.23 164.59,124.02 163.12,123.43 154.61,123.43 153.09,123.93 151.83,125.19 147.42,126.41 146.2,126.95 145.13,126.95 143.79,127.32 142.78,128.33 142.78,128.63 142.55,128.86 142.17,128.86 141.4,128.09 v1(140.6,127.86)
  BOTTOM w0.114: GPU1.D16 v1(140.6,127.86)
  BOTTOM w0.14: VRAM1.P5 v1(164.8,125.03)
FBA_WCK45: length 26.8
  L3 w0.102: v1(156.79,141.73) 156.2,142.32 156.2,142.91 155.96,143.16 153.77,143.16 153.39,142.77 147.91,142.77 145.82,144.86 141.86,144.86 141.71,145.01 139.8,145.01 138.19,143.4 138.19,141.44 138.68,140.95 138.68,139.71 138.56,139.58 v1(138.27,139.58)
  BOTTOM w0.14: GPU1.T24 138.28,139.57 v1(138.27,139.58) ; v1(156.79,141.73) 156.4,141.33 VRAM4.P4
FBA_WCK45#: length 26.9
  L3 w0.102: v1(137.68,139.01) 138.46,139.2 138.68,139.42 138.89,139.63 138.89,141.03 138.39,141.53 138.39,143.32 139.88,144.81 141.62,144.81 141.77,144.65 145.74,144.65 147.82,142.57 153.47,142.57 153.85,142.95 155.87,142.95 156,142.83 v1(156,141.73)
  BOTTOM w0.14: GPU1.U24 137.69,139.01 v1(137.68,139.01) ; v1(156,141.73) VRAM4.P5
FBA_WCK67: length 29.7
  L6 w0.089: v1(137.67,140.2) 137.71,140.24 138.9,140.24 140.3,141.64 141.69,142.54 141.7,142.54 141.72,142.55
  L6 w0.102: 141.72,142.55 142.06,142.78 149.86,143.19 163.34,143.19 164.19,142.33 164.19,142.05 164.19,141.93 v1(163.99,141.73)
  BOTTOM w0.14: v1(137.67,140.2) 137.66,140.19 GPU1.V24 ; VRAM4.D4 164.39,141.33 v1(163.99,141.73)
FBA_WCK67#: length 29.6
  L6 w0.089: v1(138.25,140.74) 138.56,140.43 138.82,140.43 140.18,141.78 141.58,142.7 141.59,142.71 141.6,142.72
  L6 w0.102: v1(164.8,141.73) 164.39,142.14 164.39,142.42 163.42,143.39 149.85,143.39 142,142.98 141.6,142.72
  BOTTOM w0.14: VRAM4.D5 v1(164.8,141.73) ; v1(138.25,140.74) 138.23,140.76 GPU1.V25
FBA_ZQ0: length 3.8
  BOTTOM w0.127: v2(160.94,115.55) R8107.1 160.05,115.52 160.05,117.91 160.37,118.23 VRAM1.J13
FBA_ZQ1: length 3.5
  BOTTOM w0.127: VRAM4.J13 160.05,148.88 160.05,150.77 R8108.1 160.07,151.03 159.54,151.56 v2(159.54,151.69)
FFS_INT1: length 28.6
  L5 w0.089: v1(108.64,92.72) 108.64,92.89 108.82,93.07 109.15,93.07 109.16,93.08 111.53,93.08 111.54,93.07 111.83,93.07 112.54,92.37 113.95,92.37 114.04,92.29 114.37,92.29 114.45,92.37 114.98,92.37 v1(116.49,93.88)
  BOTTOM w0.089: v1(108.64,92.72) 108.64,92.89 109.01,93.26 CPU1.CG22 ; v1(116.49,93.88) 116.72,93.64 118.08,93.64 118.47,93.26 120.92,93.26 121.16,93.5 v2(121.29,93.5) 121.5,93.71 125.21,93.71 125.47,93.45 127.78,93.45 128.06,93.17 129.21,93.17 129.66,92.72 133.03,92.72 133.86,93.55 U7001.12
FFS_INT2: length 37.9
  TOP w0.089: Q7001.5 137.01,92.7 R2044.2 137.01,92.7 R7011.1 136.71,91.89 136.55,92.04 136.55,92.61 136.1,93.07 v2(135.03,93.07) v1(134.47,93.07)
  L5 w0.089: v1(109.15,99.01) 109.55,99.42 114.08,99.42 114.75,98.74 118.34,98.74 118.72,98.37 118.72,96.75 119.74,95.73 119.74,93.8 v1(120.7,92.83)
  BOTTOM w0.089: CPU1.CH12 109.66,99.52 v1(109.15,99.01) ; U7001.11 134.36,93.53 134.47,93.42 v1(134.47,93.07) 133.66,93.07 133.13,92.54 129.58,92.54 129.13,92.99 127.99,92.99 127.71,93.27 125.4,93.27 125.14,93.53 121.96,93.53 121.27,92.83 v1(120.7,92.83)
FFS_INT2_Q: length 113.9
  TOP w0.089: R7014.2 139.46,93.64 139.32,93.78 v2(138.89,93.78) v1(138.22,93.78) 138.14,93.7 Q7001.6 ; v1(170.59,73.43) 170.59,73.08 171.25,72.42 171.25,68.9 171.78,68.37 171.78,64.36 171.11,63.68 v1(171.11,62.93)
  L5 w0.089: v1(138.22,93.78) 138.22,90.21 136.05,88.04 136.05,79.21 137.05,78.2 137.06,78.2 137.34,77.92 137.34,77.2 137.62,76.91 154.28,76.91 v1(154.51,76.68)
  L6 w0.089: v1(155.37,38.25) 156.12,38.25 156.97,39.1 167.47,39.1 169.32,40.95 169.87,40.95 172.52,43.6 172.52,48.81 173.15,49.44 173.15,52.56 172.73,52.98 172.73,59.84 170.71,61.86 170.71,62.54 v1(171.11,62.93) ; v1(170.59,73.43) 170.18,73.03 165.79,73.03 165.05,73.77 165.05,73.91 165.05,74.48 164.28,75.25 163.55,75.25 163.44,75.35 161.78,77.01 157.13,77.01 157.01,77.14 154.97,77.14 v1(154.51,76.68)
  BOTTOM w0.089: HDD1.9 160.15,37.96 160.02,37.83 155.79,37.83 v1(155.37,38.25)
FLT_NXP3290: length 3.2
  TOP w0.089: R7414.2 v2(42.04,120.91) 42.19,121.06 42.57,121.06 42.85,121.33 42.85,121.56 43.15,121.86 U7403.A4
FP1_USB20_CON_N: length 19.9
  BOTTOM w0.114: FP1.3 220.95,62.29 221.22,62.02 221.22,61.9 221.14,61.82 214.01,61.82 210.78,58.6 209.53,58.6 208.77,57.83 208.77,57.33 208.64,57.2 208.36,57.2 208.23,57.08 208.23,56.92 208.36,56.8 208.36,56.62 208.23,56.5 208.19,56.49 208.16,56.49 208.13,56.48 207.41,56.48 207.08,56.15 206.8,56.15 ED9202.6 206.31,56.15 205.96,56.15 R9209.1
FP1_USB20_CON_P: length 19.9
  BOTTOM w0.114: FP1.4 221.45,61.81 221.24,61.6 214.1,61.6 210.87,58.37 209.63,58.37 208.99,57.74 ED9202.1 208.27,56.27 208.19,56.26 208.14,56.25 207.5,56.25 207.18,55.92 205.81,55.92 R9210.1
FP1_USB20_N: length 136.6
  TOP w0.114: v1(204.71,57.22) v2(205.11,56.82)
  L5 w0.102: v1(204.71,57.22) 204.47,57.46 204.47,58.12 204.1,58.5 194.1,58.5 193.26,57.66 191.34,57.66 190.55,56.87 181.7,56.87 178.8,59.77 175.92,59.77 174.4,61.29 174.4,64.01 173.66,64.75 173.16,64.75 172.12,64.75 170.47,66.4 159.68,66.4 159.5,66.57 131.33,66.57 124.59,73.32 124.59,92.81 121.49,95.91 121.49,97.77 121.06,98.2 121.06,98.91 120.32,99.65 120.32,102.27 119.1,103.49 116.91,103.49 116.7,103.28 113.23,103.28 111.77,104.75 110.56,104.75 109.69,103.88 109.58,103.88 v1(109.31,104.14)
  BOTTOM w0.114: CPU1.CG5 v1(109.31,104.14) ; R9209.2 204.75,56.44 204.49,56.17 204.33,56.17 204.24,56.26 204.24,56.78 204.68,57.22 v1(204.71,57.22)
FP1_USB20_P: length 136.5
  TOP w0.114: v2(204.05,57.79) v1(204.05,57.23)
  L5 w0.102: v1(109.32,103.47) 109.52,103.68 109.77,103.68 110.64,104.54 111.68,104.54 113.15,103.08 116.79,103.08 117,103.29 119.02,103.29 120.12,102.19 120.12,99.57 120.86,98.83 120.86,98.12 121.29,97.69 121.29,95.83 124.39,92.73 124.39,73.23 131.25,66.37 159.41,66.37 159.59,66.19 170.39,66.19 172.04,64.54 173.24,64.54 173.58,64.54 174.2,63.92 174.2,61.21 175.84,59.56 178.72,59.56 181.61,56.67 190.64,56.67 191.42,57.46 193.35,57.46 194.19,58.29 204.02,58.29 204.27,58.04 204.27,57.45 v1(204.05,57.23)
  BOTTOM w0.114: R9210.2 204.45,55.73 204.02,56.16 204.02,57.2 v1(204.05,57.23) ; CPU1.CG6 108.79,103.34 108.92,103.47 109.31,103.47 v1(109.32,103.47)
FP_3D3V: length 93
  TOP w0.254: v1(166.09,72.37) 166.09,72.09 165.76,71.76 164.85,71.76 Q9201.D ; R9201.1 207.08,65.41 207.29,65.2 AFTP9201.1 214.48,65.2 214.63,65.05 v1(214.63,65.03) 214.63,64.82 215.17,64.29 218.78,64.29 218.9,64.4 219.74,64.4 219.86,64.29 v1(220.4,64.29)
  TOP w0.305: 222.48,65.3 221.92,64.74 R9211.1 ; 222.48,65.3 221.01,65.3 220.41,64.71 220.41,64.3 v1(220.4,64.29) ; 222.48,65.3 C9201.1 C9202.1
  L3 w0.254: v1(207.34,55.49) 207.34,56.44 v1(205.87,57.91) 205.4,58.38 198.55,58.38 197.54,59.4 183.92,59.4 179.93,63.39 179.93,66.51 178.52,67.92 177.19,67.92 174.04,71.07 v1(174.04,72.26)
  BOTTOM w0.254: v1(174.04,72.26) 174.04,71.68 173.8,71.43 167.03,71.43 v1(166.09,72.37) ; v1(220.4,64.29) 220.32,64.29 219.95,63.92 FP1.1 ; v1(207.34,55.49) 207.3,55.49 207.27,55.45 ED9202.5 ; v1(205.87,57.91) 206.38,57.91 207.7,59.24 207.7,62.25 207.54,62.41 207.54,62.41 207.24,62.71 207.24,63.35 208.92,65.03 v1(214.63,65.03)
FP_EN#: length 7.6
  TOP w0.089: R9212.2 166.8,70.18 165.89,69.27 164.7,69.27 164.39,68.96 C9203.1 163.65,68.97 Q9201.G 162.79,70.73 v2(162.31,70.73) Q9202.D
FPR_SCAN#: length 302.6
  TOP w0.089: v1(221.46,64.03) 221.01,64.03 220.78,63.81 219.92,63.81 219.62,64.11 219.02,64.11 218.88,63.96 214.84,63.96 214,64.8 213.67,64.8 213.57,64.9 203.71,64.9 R9201.2 ; v1(28.73,55.68) 28.3,56.11 28.3,57.22 28.76,57.67 U2401.42 ; v1(132.82,33.96) 132.82,39.33 AFTP9204.1 134.87,39.57 135.07,39.77 v1(135.07,41.32)
  L3 w0.089: v1(132.82,33.96) 132.82,33.56 134.5,31.88 144.18,31.88 145.64,33.35 149.91,33.35 151.1,34.54 166.35,34.54 166.47,34.41 168.28,34.41 168.49,34.21 173.14,34.21 175.35,32 176.41,32 189.11,32 189.84,31.27 198.33,31.27 199.37,32.31 205.08,32.31 209.87,37.1 212.09,37.1 212.6,36.59 215.86,36.59 216.16,36.9 216.16,36.91 216.26,37.01 216.41,37.16 216.42,37.16 216.81,37.54 218.38,37.54 219.57,38.74 220.12,38.74 221.46,40.08 221.46,40.23 v1(221.46,64.03)
  L6 w0.089: v1(28.73,55.68) 28.09,56.32 25.89,56.32 25.73,56.17 25.46,56.17 24.6,55.3 24.28,55.3 22.92,53.94 22.92,50.93 22.05,50.06 22.05,43.44 22.6,42.89 22.6,38.34 25.1,35.84 30.84,35.84 31.75,36.75 33.2,36.75 34.25,37.8 34.25,42.57 35.58,43.91 60.15,43.91 61.14,42.92 83.59,42.92 85.66,40.84 89.82,40.84 90.02,41.05 90.68,41.05 90.71,41.08 94.03,41.08 94.26,40.85 103.45,40.85 103.92,41.33 105.29,41.33 107.66,43.7 109.64,43.7 111.11,45.18 126.38,45.18 129.14,42.42 134.52,42.42 135.07,41.87 v1(135.07,41.32)
  BOTTOM w0.089: v1(221.46,64.03) 222.28,64.03 222.95,63.36 FP1.7
GC6_FB_EN_GPU: length 11.1
  TOP w0.089: v1(132.24,105.87) 132.24,105.84 v2(131.63,105.23) 131.33,104.97 131.17,104.8 131.17,100.79 R7927.1 132.32,100.26 v1(132.39,100.33)
  BOTTOM w0.089: v1(132.24,105.87) 132.26,105.84 R7959.2 133.51,106.5 R7916.2 ; v1(132.39,100.33) 132.16,100.33 R7975.1 130.77,101.72 Q7907.2
GC6_FB_EN_GPU_L: length 4.5
  BOTTOM w0.089: Q7907.5 130.77,104.25 130.97,104.45 131.94,104.45 R7952.1 ; R7952.1 132.13,103.66 Q7907.6 ; R7952.1 v2(133.32,103.96)
GC6_FB_EN_GPU_R: length 11.6
  BOTTOM w0.089: R7916.1 133.51,108.74 132.9,109.35 v2(132.9,110.39) 132.9,111.15 134.14,112.4 134.14,114.79 133.54,115.39 133.54,117.94 133.57,117.98
GC6_FB_EN_MCP: length 127.1
  TOP w0.089: v1(119.84,122.89) 119.84,123.62 117.9,125.56 116.28,125.56 109.63,132.21 109.63,135.38 111.56,137.31 118.93,137.31 v1(120.13,138.52) ; v1(106.01,148.18) 106.01,148.12 105.95,148.06 U8803.2 ; v1(129.52,103.73) 129.52,102.97 128.53,101.98 128.53,98.2 128.2,97.87 128.2,93.75 127.82,93.37 127.82,89.83 127.99,89.66 128.4,89.66 128.65,89.41 128.65,87.02 127.49,85.85 v2(127.49,84.38) v1(127.49,81.61)
  L3 w0.089: v1(122.95,81.03) 119.28,81.03 114.55,85.76 109.29,85.76 108.55,86.5 108.55,88.73 v1(108.13,89.16)
  L5 w0.089: v1(129.52,103.73) 128.89,103.73 127.02,105.6 127.02,109.8 127.64,110.42 127.64,114.92 123.51,119.05 123.51,119.78 121.54,121.75 120.18,121.75 119.84,122.08 v1(119.84,122.89)
  L6 w0.089: v1(120.13,138.52) 117.1,141.55 113.73,141.55 113.59,141.55 112.81,141.55 110.97,143.39 109.14,143.39 108.97,143.56 108.97,145.22 v1(106.01,148.18)
  BOTTOM w0.089: v1(127.49,81.61) 123.54,81.61 v1(122.95,81.03) ; CPU1.CE28 107.84,89.45 v1(108.13,89.16) ; v1(129.52,103.73) R7953.2 128.91,103.68 130.12,102.47 Q7907.3 130.12,101.5 R7975.2
GC6_THM_DIS: length 15.4
  TOP w0.089: v1(25.48,63.4) 25.19,63.69 U2401.23
  BOTTOM w0.089: R2490.2 24.37,57.52 23.48,57.52 23.37,57.63 23.02,57.63 22.93,57.54 22.07,57.54 21.87,57.74 21.87,58.58 20.89,59.56 20.89,61.86 v2(21.82,62.79) 21.93,62.9 21.93,63.41 22.27,63.75 24.34,63.75 24.44,63.65 25.23,63.65 v1(25.48,63.4)
GC6_THM_DIS#_EC: length 2.4
  BOTTOM w0.089: R2426.2 23.65,58.22 v2(23.65,57.86) 23.58,57.94 R2471.2
GC6_THM_DIS#_PCH: length 118.9
  TOP w0.089: v1(111.59,81.84) 107.99,78.25 107.99,73.18 103.02,68.21 59.78,68.21 58.25,69.75 v1(58.25,71.45)
  BOTTOM w0.089: CPU1.CL35 111.15,84.76 111.61,84.3 111.61,84.08 111.44,83.9 111.44,82.81 111.59,82.66 v1(111.59,81.84) ; v1(58.25,71.45) 55.53,71.45 53.45,69.38 46.81,69.38 45.63,70.56 39.9,70.56 38.33,68.99 34.99,68.99 32.9,66.9 32.9,65.79 32.03,64.92 32.03,56.59 30.47,55.02 28.48,55.02 27.8,55.71 27.8,58.39 26.52,59.67 v2(25.05,59.67) 25.05,59.54 24.74,59.23 R2490.1
GFX_CLK_CPU_N: length 57.8
  TOP w0.114: v1(124.19,134.95) 123.96,134.95 123.84,135.02 123.04,135.82 119.28,135.82 114.12,130.66 112.7,130.66 112.42,130.38 v1(112.1,130.38)
  BOTTOM w0.114: GPU1.AD8 124.2,134.95 v1(124.19,134.95) ; v1(112.1,130.38) 112.1,130.36 111.46,129.72 111.46,129.27 113.06,127.67 113.06,126.21 112.32,125.48 112.32,124.3 111.96,123.94 110.95,123.94 109.26,123.94 106.78,121.46 98.22,121.46 97.01,120.24 97.01,118.41 96.67,118.07 95.04,118.07 93.09,116.13 93.09,112.95 91.37,111.22 91.37,107.87 92.25,107 92.25,106.18 CPU1.AW2
GFX_CLK_CPU_P: length 57.8
  TOP w0.114: v1(112.55,129.93) 112.55,130.18 112.8,130.43 114.21,130.43 119.37,135.59 122.94,135.59 123.6,134.93 v1(123.62,134.33)
  BOTTOM w0.114: CPU1.AY3 92.47,105.52 92.47,105.53 92.47,107.09 91.6,107.97 91.6,111.13 93.32,112.85 93.32,116.04 95.13,117.84 96.76,117.84 97.23,118.31 97.23,120.15 98.32,121.23 106.88,121.23 109.36,123.71 111.04,123.71 112.06,123.71 112.55,124.21 112.55,125.38 113.29,126.12 113.29,127.76 111.69,129.36 111.69,129.62 111.89,129.82 112.09,129.82 112.18,129.74 112.42,129.74 112.55,129.86 v1(112.55,129.93) ; v1(123.62,134.33) 123.63,134.34 GPU1.AE8
GFX_PCIE_RX_N0: length 54.5
  L5 w0.102: v1(120.68,140.15) 120.54,140.15 119.63,139.24 119.63,135.75 118.47,134.59 118.47,132.39 115.85,129.77 115.85,125.73 116.3,125.29 116.3,117.19 115.37,116.26 110.79,116.26 110.69,116.36 108.92,116.36 108.79,116.49 106.54,116.49 104.17,114.12 104.17,108.8 104.72,108.25 104.72,106.21 104.27,105.75 104.27,103.31 104.28,103.29 104.28,101.73 104.09,101.54 104.09,101.24 103.7,100.8 v1(103.7,100.8)
  BOTTOM w0.114: C7602.1 121.36,139.51 120.72,140.15 v1(120.68,140.15) ; CPU1.BW9 103.8,100.81 103.71,100.81 v1(103.7,100.8)
GFX_PCIE_RX_N1: length 56
  L5 w0.102: v1(103.67,102.85) 103.25,103.27 103.25,103.96 103.38,104.09 103.38,106.14 103.86,106.63 103.86,107.79 103.36,108.3 103.36,114.45 106.2,117.3 109.13,117.3 109.26,117.17 115.04,117.17 115.48,117.62 115.48,124.72 115.04,125.17 115.04,130.26 117.66,132.88 117.66,134.92 118.47,135.74 118.47,140.04 120.34,141.91 121.36,141.91 v1(122.32,141.67)
  BOTTOM w0.114: C7604.1 122.93,141.06 v1(122.32,141.67) ; CPU1.BU6 103.57,102.85 v1(103.67,102.85)
GFX_PCIE_RX_N2: length 58.2
  L5 w0.102: v1(123.26,142.92) 122.86,142.94 121.91,142.94 121.48,142.52 120.02,142.52 117.83,140.34 117.83,136.3 117.83,135.97 117.05,135.18 117.05,133.13 114.4,130.49 114.4,124.89 114.87,124.42 114.87,117.91 114.75,117.78 109.51,117.78 109.38,117.91 105.95,117.91 102.75,114.71 102.75,104.23 102.34,103.83 102.34,103.31 102.84,102.8 v1(102.85,102.8)
  BOTTOM w0.114: v1(123.26,142.92) 123.66,142.53 C7606.1 ; v1(102.85,102.8) CPU1.BT7
GFX_PCIE_RX_N3: length 63.8
  L5 w0.102: v1(124.37,144.08) 124.1,144.35 122.42,144.35 121.2,143.13 119.74,143.13 117.22,140.62 117.22,136.22 116.21,135.2 116.21,133.15 113.8,130.74 113.8,124.58 114.26,124.11 114.26,118.7 114.07,118.5 109.94,118.5 109.93,118.52 105.46,118.52 102.14,115.19 102.14,105.34 101.32,104.53 101.32,102.27 101.32,102.26 101.32,101.53 101.63,101.22 102.25,101.22 102.7,100.77 v1(102.95,100.77)
  BOTTOM w0.089: v1(102.95,100.77) 102.95,100.89 CPU1.BU9
  BOTTOM w0.114: C7608.1 124.87,143.3 124.68,143.5 124.37,143.81 v1(124.37,144.08)
GFX_PCIE_RX_P0: length 55.4
  L5 w0.102: v1(103.68,101.46) 103.68,101.46 104.08,101.86 104.08,103.21 104.06,103.22 104.06,105.84 104.52,106.29 104.52,108.16 103.97,108.71 103.97,114.2 106.45,116.69 108.88,116.69 109,116.56 110.77,116.56 110.87,116.46 115.28,116.46 116.09,117.27 116.09,125.21 115.65,125.65 115.65,129.85 118.27,132.47 118.27,134.67 119.43,135.84 119.43,139.32 120.25,140.15 120.25,140.59 120.5,140.84 120.89,140.84 v1(121.13,140.6)
  BOTTOM w0.114: C7601.1 121.26,139.93 121.13,140.06 v1(121.13,140.6) ; CPU1.BW8 103.8,101.46 103.68,101.46 v1(103.68,101.46)
GFX_PCIE_RX_P1: length 55.6
  L5 w0.102: v1(103.66,103.48) 103.58,103.48 103.45,103.61 103.45,103.88 103.58,104.01 103.58,106.06 104.07,106.55 104.07,107.88 103.56,108.38 103.56,114.37 106.28,117.1 109.04,117.1 109.17,116.97 115.12,116.97 115.33,117.18 115.69,117.53 115.69,124.81 115.24,125.25 115.24,130.18 117.86,132.79 117.86,134.84 118.67,135.65 118.67,139.96 120.42,141.7 121.28,141.7 121.41,141.58 121.41,141.42 121.33,141.35 121.33,141.16 121.48,141.02 121.66,141.02 v1(121.87,141.22)
  BOTTOM w0.114: v1(103.66,103.48) 103.56,103.48 CPU1.BU5 ; v1(121.87,141.22) 122.44,141.22 122.58,141.08 122.58,140.6 C7603.1
GFX_PCIE_RX_P2: length 57.8
  L5 w0.102: v1(122.81,142.47) 122.81,142.61 122.69,142.74 121.99,142.74 121.57,142.32 120.1,142.32 118.04,140.25 118.04,136.39 118.04,136.39 118.04,136.05 118.04,135.88 117.25,135.09 117.25,133.05 114.61,130.4 114.61,124.97 115.08,124.5 115.08,117.82 114.83,117.58 109.42,117.58 109.3,117.7 106.03,117.7 102.95,114.62 102.95,104.15 102.54,103.74 102.54,103.39 102.59,103.34 102.74,103.34 v1(102.84,103.44)
  BOTTOM w0.114: C7605.1 123.7,141.72 123.7,142.16 123.39,142.47 v1(122.81,142.47) ; v1(102.84,103.44) 102.74,103.54 102.56,103.54 102.33,103.31 CPU1.BT6
GFX_PCIE_RX_P3: length 63.8
  L5 w0.102: v1(102.8,101.43) 102.62,101.26 102.5,101.26 102.34,101.42 101.71,101.42 101.52,101.61 101.52,102.35 101.52,102.35 101.52,104.44 102.34,105.26 102.34,115.11 105.55,118.31 109.85,118.31 109.86,118.3 114.16,118.3 114.47,118.61 114.47,124.19 114,124.66 114,130.66 116.41,133.07 116.41,135.12 117.43,136.13 117.43,140.53 119.82,142.93 121.29,142.93 122.5,144.14 123.35,144.14 123.42,144.07 123.42,143.67 123.42,143.66 123.42,143.46 123.52,143.36 123.77,143.36 123.92,143.51 v1(123.92,143.63)
  BOTTOM w0.089: CPU1.BU8 103.25,101.58 103.12,101.45 102.81,101.45 v1(102.8,101.43)
  BOTTOM w0.114: C7607.1 124.69,142.71 124.51,142.71 124.39,142.82 124.39,142.98 124.54,143.13 124.54,143.31 124.21,143.63 v1(123.92,143.63)
GFX_PCIE_TX_C_N0: length 22.1
  BOTTOM w0.076: CPU1.BW4 103.82,104.81 103.82,105.34 103.68,105.66 103.67,105.67 103.67,105.97 103.7,106.05 103.7,106.27 103.68,106.32 103.67,106.35 103.67,106.81 103.71,106.85 103.71,106.86 103.82,106.97 103.82,108.28 103.8,108.31 103.8,108.33
  BOTTOM w0.114: C1606.2 114.38,118.34 111.41,115.36 105.21,115.36 104.02,114.17 104.02,113.18 103.8,112.96 103.8,108.33
GFX_PCIE_TX_C_N1: length 24.2
  BOTTOM w0.076: 103.55,108.9 103.55,108.88 103.52,108.86 103.52,107.9 103.03,107.41 103.03,106.93 103.22,106.74 103.22,106.35 103.21,106.32 103.19,106.27 103.19,106.05 103.22,105.97 103.22,105.67 103.2,105.66 103.07,105.34 103.07,105.08 CPU1.BU4
  BOTTOM w0.114: C1608.2 114.77,119.47 111.21,115.91 104.89,115.91 103.55,114.57 103.55,108.9
GFX_PCIE_TX_C_N2: length 16.6
  BOTTOM w0.076: 102.87,109.39 102.87,109.38 102.9,109.35 102.9,108.02 102.5,107.62 102.5,106.35 CPU1.BU2
  BOTTOM w0.114: C1603.2 108.49,117.22 104.73,117.22 102.64,115.13 102.64,113.82 102.87,113.59 102.87,109.39
GFX_PCIE_TX_C_N3: length 16.9
  BOTTOM w0.076: 102.42,108.44 102.42,108.42 102.44,108.39 102.44,108.17 102.15,107.88 102.15,105.88 101.97,105.69 101.97,105.12 102.22,104.87 CPU1.BT4
  BOTTOM w0.114: 102.42,108.44 102.42,113.04 101.88,113.57 101.88,115.59 104.61,118.31 106.12,118.31 C1612.2
GFX_PCIE_TX_C_P0: length 22.1
  BOTTOM w0.076: CPU1.BW3 104,105.28 104,105.38 103.85,105.73 103.85,105.94 103.88,106.02 103.88,106.3 103.85,106.38 103.85,106.73 103.89,106.77 103.89,106.79 104,106.9 104,108.28 104.03,108.31 104.03,108.33
  BOTTOM w0.114: 104.03,108.33 104.03,112.86 104.24,113.08 104.24,114.07 105.31,115.13 111.5,115.13 112.94,116.57 114.15,117.78 114.35,117.78 114.76,117.38 114.96,117.38 115.08,117.5 115.08,117.69 C1605.2
GFX_PCIE_TX_C_P1: length 24.5
  BOTTOM w0.076: 103.32,108.9 103.32,108.88 103.34,108.86 103.34,107.98 102.85,107.49 102.85,106.86 103.04,106.67 103.04,106.38 103.01,106.3 103.01,106.02 103.04,105.94 103.04,105.73 102.89,105.38 102.89,105.28 CPU1.BU3
  BOTTOM w0.114: C1607.2 114.54,120.46 114.36,120.46 114.2,120.3 114.2,120.09 114.55,119.75 114.55,119.57 111.12,116.14 104.79,116.14 103.32,114.66 103.32,108.9
GFX_PCIE_TX_C_P2: length 15.6
  BOTTOM w0.076: CPU1.BU1 102.71,106.56 102.67,106.6 102.67,107.54 103.08,107.95 103.08,109.35 103.1,109.38 103.1,109.39
  BOTTOM w0.114: 103.1,109.39 103.1,113.68 102.87,113.91 102.87,115.04 104.83,116.99 108.34,116.99 C1604.2
GFX_PCIE_TX_C_P3: length 16.8
  BOTTOM w0.076: 102.64,108.44 102.64,108.42 102.62,108.39 102.62,108.1 102.33,107.81 102.33,105.88 102.53,105.68 102.53,105.19 102.47,105.13 102.35,105.13 102.22,105.26 CPU1.BT3
  BOTTOM w0.114: 102.64,108.44 102.64,113.13 102.11,113.67 102.11,115.5 104.7,118.09 105.96,118.09 C1611.2
GFX_PCIE_TX_N0: length 21.3
  BOTTOM w0.114: C1606.1 115.18,118.98 116.64,120.45 116.64,125.28 115.95,125.97 115.95,129.31 118.27,131.62 118.27,134.06 119.79,135.59 121.41,135.59 121.55,135.44 GPU1.AG7
GFX_PCIE_TX_N1: length 22.4
  BOTTOM w0.114: C1608.1 115.8,120.75 116.03,120.98 116.03,125.19 115.48,125.74 115.48,129.5 117.8,131.81 117.8,134.3 119.55,136.06 121.79,136.06 122.26,135.59 122.26,135.2 122.12,135.07 122.12,134.71 122.4,134.47 123.04,134.31
GFX_PCIE_TX_N2: length 30.1
  BOTTOM w0.114: GPU1.AF9 123.35,136.06 123.26,136.16 122.9,136.16 122.08,136.98 120.25,136.98 119.06,136.98 116.84,134.77 116.84,132.17 114.56,129.88 114.56,124.84 115.1,124.3 115.1,122.24 113.03,120.17 112,120.17 111.53,119.7 111.53,118.39 110.56,117.41 C1603.1
GFX_PCIE_TX_N3: length 32.8
  BOTTOM w0.114: C1612.1 107.38,118.34 110.19,118.34 110.77,118.92 110.77,121.13 111.41,121.77 113.54,121.77 114.4,122.63 114.4,124 113.86,124.55 113.86,130.17 116.11,132.42 116.11,135.1 118.69,137.68 118.77,137.68 122.39,137.68 122.65,137.41 123.06,137.41 123.28,137.19 GPU1.AG10
GFX_PCIE_TX_P0: length 21.3
  BOTTOM w0.114: 115.63,118.43 115.63,118.45 115.55,118.53 115.55,119.03 116.87,120.35 116.87,125.38 116.18,126.06 116.18,129.21 118.49,131.52 118.49,133.97 119.88,135.36 121.31,135.36 121.46,135.21 121.46,135 GPU1.AG6
GFX_PCIE_TX_P1: length 22.1
  BOTTOM w0.114: GPU1.AF7 122.69,135.09 122.69,135.48 121.88,136.28 119.45,136.28 117.57,134.4 117.57,131.91 115.26,129.6 115.26,125.64 115.8,125.1 115.8,121.08 115.66,120.93 115.36,120.93 C1607.1
GFX_PCIE_TX_P2: length 31
  BOTTOM w0.114: C1604.1 109.6,116.76 110.02,117.18 110.65,117.18 111.76,118.3 111.76,119.61 112.09,119.94 113.13,119.94 115.33,122.14 115.33,124.39 114.79,124.94 114.79,129.79 117.07,132.08 117.07,134.67 119.15,136.76 120.16,136.76 120.16,136.75 121.98,136.75 122.67,136.06 122.81,135.93 123.16,135.93 123.26,135.83 123.28,135.83 123.31,135.8 124.23,135.5
GFX_PCIE_TX_P3: length 32.8
  BOTTOM w0.114: GPU1.AG9 123.22,136.75 123.22,136.94 122.97,137.19 122.56,137.19 122.29,137.45 120.45,137.45 118.79,137.45 116.34,135 116.34,132.33 114.09,130.08 114.09,124.64 114.63,124.1 114.63,122.54 113.64,121.54 111.51,121.54 111,121.03 111,118.83 110.28,118.11 107.6,118.11 C1611.1
GPCPLL_AVDD: length 8.6
  TOP w0.305: v1(137.08,125.54) 137.21,125.67 C8051.1 136.86,126.98 C8047.1
  TOP w0.508: R8003.2 138.05,121.26 C8048.1 138.29,122.85 v2(138.29,124.07) 138.29,124.07 137.4,124.97 137.39,124.97 137.24,125.12 137.24,125.38 v1(137.08,125.54)
  BOTTOM w0.305: v1(137.08,125.54) 136.56,125.54 GPU1.F11
GPD11/LANPHYPC: length 55.9
  TOP w0.089: v2(145.07,68.98) v1(144.76,69.47) 145.23,69.94 R1721.2
  BOTTOM w0.076: 103.76,83.59 103.59,83.76 103.59,84 103.57,84.06 103.57,84.3 103.59,84.36 103.59,84.65 103.56,84.75 103.56,85.35 103.17,85.74 CPU1.BU34
  BOTTOM w0.089: 103.76,83.59 104.35,83 104.35,81.27 105.49,80.13 105.49,78.95 105.77,78.67 105.77,76.69 111.7,70.76 115.07,70.76 115.07,70.77 115.84,70.77 118.45,68.15 132.07,68.15 132.31,67.91 138.76,67.91 140.8,69.95 141.55,69.95 141.86,69.64 141.86,69.35 142.17,69.04 144.33,69.04 v1(144.76,69.47)
GPD_7: length 47.6
  TOP w0.089: R1524.2 v1(139.38,69.52) v2(139.91,69.17)
  BOTTOM w0.089: CPU1.BV35 103.83,84.8 104.17,84.46 104.17,83.74 104.71,83.2 104.71,81.42 105.85,80.28 105.85,79.1 106.12,78.82 106.12,76.84 111.85,71.12 111.99,71.12 114.92,71.12 114.92,71.12 115.98,71.12 118.6,68.51 132.22,68.51 132.46,68.26 138.13,68.26 v1(139.38,69.52)
GPIO5_FRAME_LOCK#: length 6.2
  BOTTOM w0.089: R7963.1 135.77,112.88 135.77,113.89 v2(135.36,114.3) 135.36,115.67 134.71,116.33 GPU1.A3
GPIO6_VGA_CORE_PSI: length 11.9
  BOTTOM w0.114: R7966.1 R7965.1 136.41,109.44 v2(137.48,109.44) 137.48,114.57 135.51,116.54 135.51,118.3 GPU1.A4
GPIO9_ALERT: length 19.8
  L5 w0.089: v1(136.66,116.77) 133.58,119.84 133.58,122.71 133.99,123.12 v1(134.78,123.12)
  BOTTOM w0.089: GPU1.F8 v1(134.78,123.12) ; v1(136.66,116.77) 138.19,115.23 138.19,108.59 v2(137.6,108) RN7910.2
GPIO10_FBVREF: length 34
  L5 w0.089: v1(135.31,120.27) 135.94,120.27 138.64,117.58 143.11,117.58 145.95,114.73 148.97,114.73 149.17,114.54 150.06,114.54 150.63,113.97 152.78,113.97 153.78,112.97 160.93,112.97 v1(161.09,113.13)
  BOTTOM w0.089: v2(157.71,114.45) 157.91,114.45 R7910.1 158.8,113.55 Q8101.G 160.34,112.39 v1(161.09,113.13) ; GPU1.C5 v1(135.31,120.27)
GPIO11_LCD_VDD: length 22.1
  L6 w0.089: v1(136.65,104.81) 136.15,105.32 136.15,106.83 136.73,107.41 136.73,115.93 135.77,116.9 135.77,119.05 136.26,119.54 136.26,119.88 135.77,120.37 135.77,120.43 134.78,121.42 v1(134.78,121.99)
  BOTTOM w0.089: R7961.1 135.72,105.67 135.72,105.04 v2(135.94,104.81) v1(136.65,104.81) ; GPU1.E7 v1(134.78,121.99)
GPIO13_LCD_BLEN: length 5.8
  BOTTOM w0.089: GPU1.B4 134.71,118.5 135.09,118.11 135.09,116.48 136.25,115.32 136.25,115.12 ; v2(136.26,115.12) 136.25,115.12 ; 136.25,115.12 R7913.1
GPP_E23_STRAP: length 3.8
  TOP w0.089: TP402.1 114.38,104.67 v1(114.76,105.06)
  BOTTOM w0.089: CPU1.CN4 112.54,104.85 113.01,104.85 113.42,104.44 114.14,104.44 v1(114.76,105.06)
GPP_H1_SFRM: length 126
  TOP w0.114: v1(110.79,87.16) 109.96,86.33 109.96,85.5 109.97,85.49 109.97,82.88 107.76,80.67 107.76,73.28 102.93,68.44 59.88,68.44 58.54,69.78 58.54,69.97 58.54,69.97 58.54,70.33 58.91,70.7 58.91,78.72 60.33,80.14 60.9,80.14 63.1,82.33 63.1,85.89 60.22,88.77 58.5,88.77 54.87,92.39 54.87,99.47 53.8,100.55 41.74,100.55 40.9,101.39 40.9,102.37 38.09,105.19 37.74,105.19 v2(37.14,105.79) 37.14,105.79 36.55,106.38 R1913.2
  BOTTOM w0.114: v1(110.79,87.16) 110.68,87.16 CPU1.CJ32
GPP_H2_CLKREQ0: length 128.4
  TOP w0.089: R1912.2 36.8,107.66 37.09,107.37 37.09,106.35 38.01,105.42 38.38,105.42 v2(41.13,102.67) 41.13,101.48 41.84,100.78 53.89,100.78 54.03,100.64 55.1,99.57 55.1,92.48 58.59,88.99 60.31,88.99 63.32,85.98 63.32,82.24 61,79.91 60.43,79.91 59.14,78.63 59.14,70.61 58.76,70.23 58.76,69.88 59.97,68.67 102.83,68.67 107.48,73.32 107.48,80.71 109.74,82.97 109.74,86.39 110.33,86.98 110.33,88.73 v1(109.93,89.13)
  BOTTOM w0.089: CPU1.CH29 109.89,89.13 v1(109.93,89.13)
GPP_H21: length 23.9
  TOP w0.089: v1(107.9,90.6) 107.67,90.83 v2(107.67,91.11)
  L3 w0.089: v1(107.9,90.6) 108.38,91.08 110.02,91.08 110.82,90.27 111.05,90.27 113.19,88.14 114.12,88.14 115.98,86.28 116.96,86.28 117.85,87.18 117.85,87.35 119.01,88.5 v1(119.8,88.5)
  BOTTOM w0.089: v1(119.8,88.5) 120.2,88.9 121.36,88.9 123.83,86.44 R1522.2 ; v1(107.9,90.6) 108.1,90.6 108.36,90.85 CPU1.CF25
GPP_H23: length 16
  BOTTOM w0.089: R1513.2 123.33,87.2 120.56,89.97 119.56,89.97 119.05,90.48 v2(118.54,90.48) 118.39,90.63 115.19,90.63 115.01,90.81 113.94,90.81 113.71,91.04 111.96,91.04 CPU1.CM26
GPPC_H18_VCCIO_LPM: length 170.3
  TOP w0.089: R4034.1 89.61,40.57 89.09,41.1 v2(89.03,41.1) 89.03,41.25 v1(88.7,41.58) ; v1(42.62,47.78) 43.27,47.78 43.69,48.2 43.69,49.64 44.29,50.24 44.35,50.24 53.93,59.82 54.02,59.82 101.3,59.82 101.62,60.14 106.81,60.14 115.83,69.15 115.83,70.89 117.67,72.74 117.67,77.21 123.14,82.68 123.14,86.46 121.64,87.97 119.3,87.97 117.78,89.49 v1(117.4,89.49)
  L6 w0.089: v1(42.62,47.78) 42.62,48.57 44.14,50.09 57.98,50.09 58.93,49.14 58.93,46.53 59.74,45.72 59.74,44.56 61.21,43.1 87.18,43.1 v1(88.7,41.58)
  BOTTOM w0.089: CPU1.CN27 112.89,89.82 113.77,89.82 114.1,89.49 v1(117.4,89.49)
GPU_CLKREQ#: length 45
  TOP w0.089: v1(132.51,98.17) v2(132.51,98.72)
  L6 w0.089: v1(121.87,131.36) 120.91,130.39 120.91,127 129.53,118.37 129.76,118.37 130.9,117.23 130.9,116.73 132.97,114.66 132.97,111.31 132.04,110.39 132.04,108.83 133.3,107.58 133.3,106.62 133.02,106.34 133.02,102.26 132.83,102.07 132.83,98.48 v1(132.51,98.17)
  BOTTOM w0.089: GPU1.AC6 123.3,132.31 122.9,132.31 122.9,132.31 122.81,132.31 121.87,131.37 v1(121.87,131.36) ; v1(132.51,98.17) 132.51,98.1 133.11,97.5 Q7601.S 133.54,97.5 R7603.1
GPU_EVENT_GPU#: length 8.9
  TOP w0.089: v1(135,104.88) 134.55,105.34 v2(134.55,107.47) 134.55,108.68 134.67,108.81 v1(134.91,108.81)
  BOTTOM w0.089: v1(135,104.88) 134.9,104.88 134.34,104.32 133.53,104.32 R7964.2 132.73,105.05 Q7906.S ; R7965.2 134.96,108.87 v1(134.91,108.81)
GPU_EVENT_GPU#_R: length 18.6
  L6 w0.089: v1(134.98,105.52) 134.98,105.94 136.29,107.26 136.29,116.09 134.75,117.63 v1(134.75,120.83)
  BOTTOM w0.089: R7964.1 134.39,105.08 v2(134.5,105.18) 134.83,105.52 v1(134.98,105.52) ; v1(134.75,120.83) 134.78,120.86 GPU1.D6
GPU_EVENT_MCP#: length 49.1
  TOP w0.089: v1(129.51,104.52) 128.86,103.86 128.86,102.67 128.35,102.16 128.35,98.93 128.02,98.6 128.02,96.13 128.02,96.13 128.02,93.88 127.36,93.22 v2(127.36,90.2) 127.36,87.43 127.51,87.28 v1(128.22,87.28)
  L3 w0.089: v1(121.67,89.49) 121.38,89.49 119.96,88.06 118.82,88.06 118.03,87.27 118.03,87.1 117.03,86.1 115.91,86.1 114.33,87.68 113.3,87.68 111.01,89.97 110.85,89.97 109.92,90.9 108.8,90.9 108.08,90.18 107.54,90.18 v1(107.13,90.59)
  BOTTOM w0.089: Q7906.D 129.77,104.78 v1(129.51,104.52) R7948.1 ; v1(128.22,87.28) 128.22,87.28 127.1,88.39 127.1,89.71 126.76,90.06 122.02,90.06 121.67,89.71 v1(121.67,89.49) ; v1(107.13,90.59) 107.13,90.5 CPU1.CC27
GPU_I2C:
  vias: v2(142.31,105.23)
GPU_I2CA_SCL: length 14.9
  BOTTOM w0.114: RN7701.1 138.43,107.59 138.71,107.87 v2(138.71,108.57) 138.71,110.45 138.53,110.63 138.53,116.9 136.82,118.6 136.82,120.03 136.47,120.38 GPU1.B7
GPU_I2CA_SDA: length 14.7
  BOTTOM w0.114: 137.04,120.31 137.04,118.77 138.78,117.03 138.78,110.86 139.75,109.88 v2(139.75,107.95) 139.1,107.29 RN7701.2
GPU_PEX_RST#: length 47.3
  L6 w0.089: v1(132.33,101.85) 132.36,101.85 132.84,102.33 132.84,106.28 131.52,107.59 131.52,110.12 132.79,111.39 132.79,114.54 130.71,116.62 130.71,117.15 129.68,118.18 129.43,118.18 120.5,127.12 120.5,130.62 123.66,133.79 v1(124.15,133.79)
  BOTTOM w0.089: v1(124.15,133.79) 124.15,133.74 124.17,133.72 GPU1.AC7 ; R7614.1 138.2,100.79 R7613.2 136.53,100.79 v2(136.5,100.76) 136.41,100.67 134.38,100.67 133.93,101.13 U7602.4 133.06,101.13 v1(132.33,101.85)
GPU_PEX_RST_HOLD: length 8.1
  TOP w0.089: v1(136.61,103.93) 135.87,104.67 135.87,107.7 135.77,107.8 v1(135.77,107.85)
  BOTTOM w0.089: v2(136.96,103.48) 136.96,103.57 v1(136.61,103.93) 136.17,103.48 R7931.2 135.96,103.18 135.84,103.06 135.31,103.06 135.21,102.96 U7602.1 ; R7973.2 136.12,107.85 v1(135.77,107.85)
GPU_PEX_RST_HOLD_GPU#: length 15.3
  BOTTOM w0.089: GPU1.C4 134.62,119.67 136.06,118.22 136.06,116.49 137.83,114.72 137.83,109.23 137.57,108.97 137.24,108.97 R7973.1 136.99,108 136.23,107.25 v2(136.01,107.25)
GPU_PWR_LEVEL: length 300.2
  TOP w0.127: v1(21.54,68.4) 21.54,68.45 21.77,68.68 22.85,68.68 23.06,68.89 U2401.10 ; v1(151.79,111.51) v2(152.63,111.51) 152.83,111.51 154.18,110.16 154.18,107.49 155.01,106.66 155.01,102.69 157.83,99.88 157.83,99.87 157.85,99.84 157.85,98.52 159.64,96.73 v1(159.64,94.79) ; v1(168.97,76.35) 168.82,76.21 168.82,73.85 169.09,73.58 169.09,71.9 170.36,70.63 170.36,68.74 170.84,68.27 170.84,65.48 170.12,64.76 170.12,64.4 169.54,63.82 169.54,62.6 v1(169.4,62.46)
  L5 w0.127: v1(159.64,94.79) 160.07,94.36 160.07,90.67 160.76,89.99 160.76,87.35 165.46,82.65 165.46,79.8 168.9,76.35 v1(168.97,76.35) ; v1(21.54,68.4) 21.54,67.86 20.11,66.43 20.11,62.85 14.58,57.33 14.58,51.54 14.44,51.39 14.44,48.67 12.28,46.52 12.28,44.21 14.53,41.96 14.53,35.44 14.77,35.2 14.77,31.46 21.79,24.44 30.49,24.44 32.13,26.08 32.13,26.92 36.49,31.28 61.05,31.28 61.7,31.93 82.93,31.93 83.55,32.54 85.54,32.54 v1(86.46,31.62) ; v1(145.04,37.54) 145.04,37.54 145.57,38.08 150.83,38.08 151.92,39.17 153.85,39.17 v1(154.89,40.21)
  L6 w0.127: v1(86.46,31.62) 88.19,33.35 103.01,33.35 103.64,33.99 103.64,35.37 105.64,37.37 105.64,37.7 108.49,40.55 108.9,40.55 112.29,43.94 124.59,43.94 128.47,40.07 129.77,40.07 130.46,39.38 143.2,39.38 v1(145.04,37.54) ; v1(154.89,40.21) 154.89,40.24 155.81,41.16 168.33,41.16 168.93,41.76 169.63,41.76 171.55,43.67 171.55,53.62 171.95,54.02 171.95,59.54 169.4,62.1 v1(169.4,62.46)
  BOTTOM w0.127: v1(159.64,94.79) 159.85,95 PQ4402.D ; D7902.K 150.86,111.51 v1(151.79,111.51)
GPU_ROM: length 16.7
  BOTTOM w0.089: v2(150.1,119.91) 150.12,119.92 150.12,120.83 149.63,121.31 R7935.1 149.26,121.32 R7918.1 ; v2(150.1,119.91) R7920.1 148.13,118.15 R7947.1 ; v2(150.1,119.91) 151.19,119.91 152.76,118.34 152.76,115.22 153.37,114.61 153.37,113.31 153.77,112.9 R7946.1
GPU_ROM_SCLK: length 12.7
  BOTTOM w0.114: GPU1.C12 138.85,124.35 139.07,124.13 139.07,123.67 139.4,123.33 139.4,123.29 139.42,123.28 139.42,123.02 142.52,119.91 142.95,119.91 143.32,119.55 143.32,119.55 143.93,118.94 v2(145.77,118.94) R7920.2 148.06,119.74 R7921.1
GPU_ROM_SI: length 11.9
  BOTTOM w0.114: R7935.2 148.39,120.85 R7924.1 147.65,120.52 146.87,119.74 143.52,119.74 v2(142.89,120.37) 142.18,121.08 141.65,121.08 139.63,123.11 139.63,123.6 GPU1.B12
GPU_ROM_SO: length 11.5
  BOTTOM w0.114: GPU1.A12 139.98,123.12 141.61,121.49 v2(142.42,121.49) 143.83,120.08 146.35,120.08 148.36,122.09 R7918.2 R7932.1
GPU_THM_SMBCLK: length 381
  TOP w0.114: v1(35.06,102.9) 34.84,102.68 Q5801.3 ; R2460.2 215.27,54.66 214.76,55.17 214.76,55.61 214.61,55.77 214.61,57.88 212.65,59.83 212.65,60.34 v2(211.38,61.62) 210.99,62.01 210.99,63.22 210.52,63.69 208.52,63.69 v1(207.75,62.92) 207.39,62.92 206.91,62.43 204.7,62.43 203.3,63.83 200.79,63.83 199.85,64.77 R2459.2 ; v1(21.91,66.48) 21.91,67.53 22.48,68.09 U2401.12
  L3 w0.089: v1(141.23,33.58) 144.63,33.58 145.12,34.07 145.14,34.07 145.15,34.08 149.57,34.08 150.77,35.28 165.71,35.28 166.45,36.01 166.76,36.01 167.81,36.01 168.17,35.65 172.75,35.65 175.65,32.74 189.44,32.74 190.17,32.01 197.77,32.01 200.27,34.52 205.81,34.52 209.31,38.01 212.47,38.01 212.97,37.51 215.47,37.51 216.03,38.07 216.04,38.07 216.43,38.46 217.19,38.46 217.9,38.46 218.54,39.1 218.54,54.79 214.18,59.15 213.48,59.15 210.55,62.08 208.59,62.08 v1(207.75,62.92)
  L6 w0.114: v1(35.06,102.9) 34.27,102.11 34.27,100.81 37.62,97.46 37.62,95.23 37.63,95.23 37.63,95.17 37.88,94.92 41.33,94.92 43.28,92.97 43.28,86.23 44.54,84.98 44.54,84.8 44.54,82.03 43.11,80.59 43.11,75.77 42.39,75.05 41.6,75.05 40.94,74.39 40.94,73.27 38.33,70.66 35.99,70.66 34.27,72.38 29.85,72.38 28.39,70.92 26.04,70.92 21.91,66.79 v1(21.91,66.48) 21.87,66.44 21.87,64.62 23.04,63.45 23.04,61.57 22.18,60.71 21.49,60.71 19.53,58.75 19.53,40.25 20.85,38.93 20.85,35.97 21.12,35.7 21.12,27.57 23.03,25.67 37.05,25.67 41.26,29.88 89.04,29.88 90.64,31.48 104.26,31.48 107.33,34.56 108.24,34.56 110.81,37.12 110.81,41.01 112.66,42.86 123.97,42.86 128.13,38.7 128.97,38.7 129.58,38.09 138.09,38.09 140.11,36.07 141.76,36.07 142.27,35.56 142.27,34.9 141.23,33.86 v1(141.23,33.58)
GPU_THM_SMBDAT: length 384.7
  TOP w0.114: R2455.2 214.51,55.53 214.37,55.67 214.37,57.78 212.41,59.73 212.41,60.06 210.75,61.72 210.75,63.12 210.42,63.45 208.92,63.45 v1(208.38,62.92) 207.7,62.23 v2(207.55,62.23) 207.05,62.23 207.01,62.19 204.6,62.19 203.2,63.59 200.36,63.59 199.94,64.01 R2447.2 ; v1(21.34,66.22) 21.34,67.29 22.47,68.42 22.98,68.42 23.05,68.49 U2401.11 ; Q5801.6 32.81,101.03 32.52,101.32 32.52,102.72 32.69,102.9 v1(33.15,102.9)
  L3 w0.089: v1(208.38,62.92) 209.02,62.28 210.62,62.28 213.56,59.34 214.26,59.34 218.73,54.86 218.73,38.92 218.08,38.27 217.11,38.27 217.11,38.27 216.51,38.27 216.12,37.88 216.11,37.88 215.55,37.32 212.9,37.32 212.39,37.82 209.39,37.82 205.89,34.33 200.35,34.33 197.84,31.81 190.09,31.81 189.36,32.55 175.57,32.55 173.37,34.75 168.8,34.75 167.73,35.82 166.69,35.82 166.68,35.82 166.53,35.82 165.79,35.09 150.85,35.09 149.65,33.89 145.23,33.89 144.5,33.15 141.02,33.15 v1(140.59,33.58)
  L6 w0.114: v1(33.15,102.9) 34.01,102.03 34.01,100.71 37.37,97.36 37.37,95.13 37.79,94.7 41.24,94.7 43.07,92.88 43.07,86.14 44.33,84.89 44.33,82.12 42.89,80.68 42.89,75.86 42.3,75.27 41.51,75.27 40.73,74.48 40.73,73.36 38.24,70.88 36.08,70.88 34.36,72.6 29.76,72.6 28.3,71.14 25.95,71.14 21.34,66.52 v1(21.34,66.22) 21.64,65.91 21.64,64.54 22.82,63.36 22.82,61.66 22.09,60.92 21.4,60.92 19.31,58.83 19.31,40.16 20.63,38.84 20.63,35.89 20.91,35.61 20.91,27.48 22.94,25.45 37.14,25.45 41.35,29.67 89.13,29.67 90.73,31.27 104.35,31.27 107.42,34.34 108.33,34.34 111.03,37.03 111.03,40.92 112.75,42.65 123.88,42.65 128.04,38.48 128.88,38.48 129.49,37.87 138,37.87 140.02,35.85 141.66,35.85 142.05,35.46 142.05,35.03 141.04,34.02 141.03,34.02 v1(140.59,33.58)
GSENSOR_CS: length 3.2
  TOP w0.254: R7006.1 133.12,94.38 132.95,94.56 v1(132.56,94.72) 132.49,94.72 v2(131.94,94.17)
  BOTTOM w0.254: v1(132.56,94.72) 132.64,94.72 133.06,94.3 U7001.2
GSENSOR_SDO: length 2.4
  TOP w0.089: v2(131.91,95.39) v1(132.56,95.39) 132.67,95.51 R7007.2
  BOTTOM w0.089: U7001.3 133.14,94.8 v1(132.56,95.39)
H_CPUPWRGD: length 10.6
  BOTTOM w0.089: CPU1.AR2 89.88,106.25 89.88,109.48 89.79,109.56 89.79,110.1 89.88,110.19 v2(89.88,113.16) 89.88,114.04 89.24,114.68 ED301.2 89.15,114.63 R1714.1
H_PECI: length 3
  TOP w0.114: U2401.94 40.15,71.69 v2(40.26,71.81) 40.49,72.04 C2405.1 R2437.1
HDA_BITCLK_CODEC: length 144.7
  TOP w0.114: v1(115.95,68) 106.72,58.76 100.8,58.76 100.42,59.15 54.3,59.15 47.24,52.08 47.24,52.08 46.43,51.28 45.14,49.98 45.14,46.57 44.83,46.26 43.21,46.26 42.77,46.69 41.96,46.69 41.51,46.24 41.51,44.26 40.76,43.52 37.46,43.52 36.29,43.52 35.03,42.25 35.03,41.45 34.42,40.84 31.38,40.84 28.51,37.98 28.51,36.55 26.34,34.37 26.34,33.73 26.34,33.72 v2(26.34,33.2) 26.33,33.19 26.33,29.73 25.06,28.46 25.06,28.44 25.05,28.42 25.05,27.96 24.95,27.86 24.69,27.86 24.58,27.75 24.58,27.52 24.69,27.4 24.93,27.4 25.05,27.29 25.05,26.46 24.93,26.33 24.59,26.33 24.41,26.15 24.41,25.93 24.54,25.81 25.12,25.81 25.25,25.68 25.25,23.98 24.82,23.55 24.82,22.56 EC2706.1 25.43,21.95 25.61,21.95 26.53,21.02 EC1901.2 26.65,20.65 26.85,20.45 ER2701.1
  BOTTOM w0.114: v1(115.95,68) 115.5,67.54 113.22,67.54 103.53,77.23 R1920.1
