# Allegro board 18750-1.1227WZS1652.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R2505  0R2J-L-GP  [R402H15]  159.44 94.06 90 top
R2506  4K7R2J-2-GP  [R402H16]  164.72 92.03 270 top
R2507  33R2F-3-GP  [R402H16]  134.42 91.59 90 bottom
R2508  33R2F-3-GP  [R402H16]  131.14 78.92 180 bottom
R2509  33R2F-3-GP  [R402H16]  133.45 78.92 180 bottom
R2510  33R2F-3-GP  [R402H16]  136.47 79.26 90 top
R2511  33R2F-3-GP  [R402H16]  134.5 90.3 180 top
R2512  33R2F-3-GP  [R402H16]  138.15 90.55 180 top
R2513  33R2F-3-GP  [R402H16]  135.68 90.49 90 top
R2514  10KR2J-3-GP  [R402H16]  155.83 93.3 180 bottom
R2515  0R0402-PAD-1-GP  [0R0402-PAD]  134.01 90.3 0 bottom
R2516  0R0402-PAD-1-GP  [0R0402-PAD]  155.07 98.48 180 top
R2517  47KR2F-GP  [R402H16]  159.39 93.3 270 top
R2518  100KR2J-1-GP  [R402H16]  166.65 89.22 90 top
R2519  4K7R2J-2-GP  [R402H16]  127.51 86.21 0 bottom
R2520  100KR2J-1-GP  [R402H16]  155.07 93.3 180 bottom
R2521  4K7R2J-2-GP  [R402H16]  132.45 79.31 90 top
R2567  1MR2J-1-GP  [R402H16]  166.7 91.4 180 top
R2601  0R1J-GP  [R0201H12]  122.81 114.18 45 top
R2602  -  [0R0402-PAD]  128.88 105.81 0 bottom
R2603  7K5R2F-1-GP  [R402H16]  126.37 113.54 225 top
R2604  7K5R2F-1-GP  [R402H16]  125.17 112.27 225 top
R2607  10KR2J-3-GP  [R402H16]  41.51 69.22 270 top
R2608  27KR2F-L-GP  [R402H16]  19.61 64.52 90 bottom
R2610  NTC-100K-8-GP  [NTC-603H38]  41.63 80.09 270 bottom
R2612  0R0402-PAD-1-GP  [0R0402-PAD]  158.98 89.28 270 top
R2613  -  [0R0402-PAD]  159.41 86.56 180 top
R2614  -  [0R0402-PAD]  159.41 84.89 180 top
R2615  0R1J-GP  [R0201H12]  130.56 108 90 bottom
R2616  0R1J-GP  [R0201H12]  128.73 108.73 315 bottom
R2617  2K2R2J-2-GP  [R402H16]  126.03 113.64 45 bottom
R2618  2K2R2J-2-GP  [R402H16]  127.69 114.05 45 bottom
R2701  -  [0R0805-PAD]  34.01 17.55 270 top
R2702  100KR2J-1-GP  [R402H16]  22.41 9.45 270 top
R2703  0R0402-PAD-1-GP  [0R0402-PAD]  18.49 11.58 0 top
R2704  0R0402-PAD-1-GP  [0R0402-PAD]  34.78 8 90 top
R2705  0R0402-PAD-1-GP  [0R0402-PAD]  32.64 4.62 0 top
R2708  0R0402-PAD-1-GP  [0R0402-PAD]  20.4 14.81 90 top
R2709  0R0402-PAD-1-GP  [0R0402-PAD]  31.3 6.96 270 top
R2710  100KR2F-L1-GP  [R402H16]  21.54 20.14 0 top
R2711  200KR2F-L-GP  [R402H16]  21.11 18.39 90 top
R2712  0R0402-PAD-1-GP  [0R0402-PAD]  31.6 16.05 270 top
R2715  0R0402-PAD-1-GP  [0R0402-PAD]  28.27 21.97 0 top
R2717  100KR2J-1-GP  [R402H16]  30.69 16.87 90 top
R2724  33R2J-2-GP  [R402H16]  24.87 19.64 0 top
R2725  0R0402-PAD-1-GP  [0R0402-PAD]  34.65 11.94 270 top
R2735  2K2R2J-L1-GP  [R402H16]  22.3 19.51 180 top
R2736  -  [0R0805-PAD]  34.01 15.72 270 top
R2738  0R2J-2-GP  [R402H16]  27.79 17.96 0 top
R2739  1KR2J-1-GP  [R402H16]  23.02 25.2 0 top
R2740  1KR2J-1-GP  [R402H16]  24.39 25.3 270 top
R2906  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  16.82 10.24 0 top
R2907  0R0402-PAD-1-GP  [0R0402-PAD]  21.24 9.25 0 top
R2908  10R2F-L1-GP  [R402H16]  25.91 9.58 270 top
R2909  0R0402-PAD-1-GP  [0R0402-PAD]  18.7 9.88 0 top
R2910  10R2F-L1-GP  [R402H16]  27.31 7.67 0 top
R2911  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  16.79 17.22 180 top
R2912  4K7R2J-2-GP  [R402H16]  28.07 7.67 180 top
R2913  4K7R2J-2-GP  [R402H16]  26.39 8.36 180 top
R2914  0R0402-PAD-1-GP  [0R0402-PAD]  18.32 18.37 90 top
R2921  1KR2J-1-GP  [R402H16]  27.56 9.4 90 top
R2922  1KR2J-1-GP  [R402H16]  25.61 8.36 180 top
R2923  0R0402-PAD-1-GP  [0R0402-PAD]  17 15.65 90 top
R2924  0R0402-PAD-1-GP  [0R0402-PAD]  16.97 1.86 270 top
R2925  0R0402-PAD-1-GP  [0R0402-PAD]  16.97 3.09 270 top
R2926  0R0402-PAD-1-GP  [0R0402-PAD]  16.97 4.31 270 top
R2927  0R0402-PAD-1-GP  [0R0402-PAD]  17.05 5.53 270 top
R3101  -  [0R0402-PAD]  48.42 86.74 0 bottom
R3102  2K49R2F-GP  [R402H16]  42.7 86.49 270 bottom
R3103  1KR2J-1-GP  [R402H16]  50.32 84.84 180 top
R3104  0R2J-2-GP  [R402H16]  50.22 86.06 90 top
R3109  1KR2J-1-GP  [R402H16]  48.62 79.55 270 bottom
R3113  15KR2J-1-GP  [R402H16]  48.09 83.14 90 bottom
R3202  510R2J-1-GP  [R402H16]  17.02 59.74 180 top
R3203  0R2J-2-GP  [R402H16]  17.86 61.22 180 bottom
R3501  0R0402-PAD-1-GP  [0R0402-PAD]  19.26 54.45 270 bottom
R3502  0R0402-PAD-1-GP  [0R0402-PAD]  19.28 52.9 270 bottom
R3503  0R0402-PAD-1-GP  [0R0402-PAD]  19.59 44.93 270 bottom
R3504  0R0402-PAD-1-GP  [0R0402-PAD]  19.56 43.37 270 bottom
R3505  0R0402-PAD-1-GP  [0R0402-PAD]  19.56 42.61 270 bottom
R3506  0R0402-PAD-1-GP  [0R0402-PAD]  19.59 44.16 270 bottom
R3507  0R0402-PAD-1-GP  [0R0402-PAD]  19.26 53.66 270 bottom
R3508  0R0402-PAD-1-GP  [0R0402-PAD]  19.28 52.09 270 bottom
R3512  0R0402-PAD-1-GP  [0R0402-PAD]  20.7 43.23 90 top
R3601  0R0402-PAD-1-GP  [0R0402-PAD]  16.92 52.86 180 top
R3602  100KR2J-1-GP  [R402H16]  18 50.55 90 top
R3603  20KR2F-L-GP  [R402H16]  23.12 51.21 180 top
R3604  22K1R2F-L-GP  [R402H16]  22.89 51.11 270 bottom
R3605  100KR2J-1-GP  [R402H16]  18.09 54.92 90 top
R3606  100KR2J-1-GP  [R402H16]  18 51.31 90 top
R3607  0R0402-PAD-1-GP  [0R0402-PAD]  20.7 43.99 270 top
R3610  0R2J-L-GP  [R402H15]  22.74 56.01 180 top
R3611  0R2J-L-GP  [R402H15]  22.74 54.41 0 top
R3612  0R2J-L-GP  [R402H15]  22.33 55.6 90 top
R3613  0R2J-L-GP  [R402H15]  22.33 54.81 90 top
R3614  0R2J-L-GP  [R402H15]  21.83 48.38 315 bottom
R3615  0R2J-L-GP  [R402H15]  21.27 48.93 315 bottom
R3616  0R2J-L-GP  [R402H15]  22.41 48.38 45 bottom
R3617  0R2J-L-GP  [R402H15]  21.27 49.51 225 bottom
R3618  0R5J-5-GP  [R805H24]  17.12 37.77 180 top
R4002  -  [0R0402-PAD]  82.55 152.45 90 bottom
R4005  1KR2J-1-GP  [R402H16]  83.65 153.7 180 bottom
R4006  20KR2F-L-GP  [R402H16]  147.21 71.48 0 top
R4009  10KR2J-3-GP  [R402H16]  24.36 68.94 180 bottom
R4010  20KR2J-L3-GP  [R402H16]  89.03 34.72 90 top
R4011  0R0402-PAD-1-GP  [0R0402-PAD]  82.68 37.72 90 top
R4014  0R2J-L-GP  [R402H15]  146.74 72.82 270 top
R4017  0R2J-L-GP  [R402H15]  88.4 40.18 90 top
R4024  0R0402-PAD-1-GP  [0R0402-PAD]  114.48 115.95 90 bottom
R4029  -  [0R0402-PAD]  95.56 139.98 270 top
R4030  -  [0R0402-PAD]  21.72 58.68 0 top
R4031  100KR2J-1-GP  [R402H16]  76.18 37.03 270 bottom
R4033  0R2J-L-GP  [R402H15]  78.24 36.63 180 top
R4034  0R2J-L-GP  [R402H15]  89.61 39.83 0 top
R4036  0R0402-PAD-1-GP  [0R0402-PAD]  118.35 115.38 90 top
R4038  0R0402-PAD-1-GP  [0R0402-PAD]  109.64 126.37 90 top
R4040  0R2J-L-GP  [R402H15]  90.4 40.26 0 top
R4047  0R0402-PAD-1-GP  [0R0402-PAD]  42.32 88.19 0 top
R4048  20KR2J-L3-GP  [R402H16]  89.03 36.37 90 top
R4301  -  [0R0402-PAD]  134.88 34.04 90 top
R4302  15KR2F-GP  [R402H16]  20.42 95.63 90 top
R4303  10KR2J-3-GP  [R402H16]  18.82 99.49 90 top
R4304  2K2R2J-2-GP  [R402H16]  25.43 94.51 270 top
R4305  33R2J-2-GP  [R402H16]  24.26 95.05 0 top
R4307  240KR3-GP  [R603H22]  28.06 129.01 0 top
R4308  47KR2F-GP  [R402H16]  29.52 127.71 90 top
R4309  100KR2J-1-GP  [R402H16]  26.44 97.69 0 top
R4311  100KR2F-L1-GP  [R402H16]  33.96 132.03 90 top
R4312  1KR2F-3-GP  [R402H16]  27.44 122.15 0 top
R4315  18K7R2F-GP  [R402H16]  33.53 133.3 0 top
R4316  20KR2J-L2-GP  [R402H16]  28.81 132.18 270 top
R4376  470KR2F-GP  [R402H16]  26.34 124.91 90 top
R4377  84K5R2F-GP  [R402H16]  41.79 118.04 0 top
R4378  100KR2J-1-GP  [R402H16]  37.4 117.93 180 top
R4464  100KR2J-1-GP  [R402H16]  35.41 127.26 90 top
R4465  10KR2F-2-GP  [R402H16]  37.09 126.47 270 top
R4466  0R2F-1-GP  [R402H16]  37.09 127.28 90 top
R4467  100KR2F-L1-GP  [R402H16]  28.73 122.33 270 top
R4468  100KR2F-L1-GP  [R402H16]  33.63 127.23 270 top
R4469  0R2F-1-GP  [R402H16]  32.03 127.7 90 top
R4470  0R2F-1-GP  [R402H16]  30.54 121.54 180 top
R4471  0R2F-1-GP  [R402H16]  35.59 131.99 270 top
R4481  0R2F-1-GP  [R402H16]  26.66 122.4 180 top
R4482  0R2F-1-GP  [R402H16]  26.66 120.8 180 top
R5501  0R3J-L1-GP  [R603H22]  156.72 101.27 270 bottom
R5502  0R3J-L1-GP  [R603H22]  165.48 86.54 180 top
R5504  100R2J-2-GP  [R402H14]  212.56 63.57 90 top
R5511  0R2J-2-GP  [R402H16]  213.08 46.92 270 top
R5512  0R2J-2-GP  [R402H16]  213.09 47.69 270 top
R5517  4K7R2J-2-GP  [R402H16]  224.72 42.9 270 top
R5518  4K7R2J-2-GP  [R402H16]  223.14 42.9 270 top
R5533  0R2J-2-GP  [R402H16]  112.96 104.32 90 top
R5544  100KR2J-1-GP  [R402H16]  112.83 103.53 270 top
R5545  0R0402-PAD-1-GP  [0R0402-PAD]  47.53 66.93 90 top
R5546  4K7R2F-GP  [R402H16]  134.45 78.87 180 bottom
R5547  100KR2F-L1-GP  [R402H16]  46.56 64.87 270 top
R5548  4K7R2F-GP  [R402H16]  221.9 66.27 0 top
R5549  1MR2F-GP  [R402H16]  49.36 65.56 180 top
R5550  0R0402-PAD-1-GP  [0R0402-PAD]  225 64.7 90 top
R5551  0R0402-PAD-1-GP  [0R0402-PAD]  139.53 89.94 180 bottom
R5552  200KR2F-L-GP  [R402H16]  220.58 68.45 0 top
R5553  10KR2F-2-GP  [R402H16]  213.54 66.55 90 top
R5554  10KR2F-2-GP  [R402H16]  136.27 92.48 90 bottom
R5555  200KR2F-L-GP  [R402H16]  139.63 93.96 0 bottom
R5556  10KR2J-3-GP  [R402H16]  156.87 103.25 90 bottom
R5557  0R2J-2-GP  [R402H16]  154.47 107.53 270 bottom
R5558  -  [0R0402-PAD]  154.76 105.53 0 bottom
R5559  0R0402-PAD-1-GP  [0R0402-PAD]  155.96 105.21 90 top
R5560  0R2J-2-GP  [R402H16]  155.16 107.17 45 top
R5564  10KR2J-3-GP  [R402H16]  155.96 104.45 270 top
R5565  0R2J-2-GP  [R402H16]  212.75 50.8 0 bottom
R5601  0R0402-PAD-1-GP  [0R0402-PAD]  201.37 62.28 90 top
R5605  0R0402-PAD-1-GP  [0R0402-PAD]  53.98 122.61 90 bottom
R5705  470R2F-GP  [R402H16]  22.61 95.12 0 bottom
R5751  2K2R2J-2-GP  [R402H16]  17.66 88.83 90 top
R5755  2K2R2J-2-GP  [R402H16]  19.56 88.83 90 top
R5759  470R2F-GP  [R402H16]  22.61 93.42 180 bottom
R5764  200KR2F-L-GP  [R402H16]  16.94 107.93 180 bottom
R5765  0R0402-PAD-1-GP  [0R0402-PAD]  19.59 94.29 90 bottom
R5766  0R0402-PAD-1-GP  [0R0402-PAD]  19.59 95.05 90 bottom
R5767  0R0402-PAD-1-GP  [0R0402-PAD]  19.61 95.84 90 bottom
R5768  0R0402-PAD-1-GP  [0R0402-PAD]  19.61 96.6 90 bottom
R5769  0R0402-PAD-1-GP  [0R0402-PAD]  19.61 97.38 90 bottom
R5770  0R0402-PAD-1-GP  [0R0402-PAD]  19.61 98.15 90 bottom
R5771  0R0402-PAD-1-GP  [0R0402-PAD]  19.61 98.96 90 bottom
R5772  0R0402-PAD-1-GP  [0R0402-PAD]  19.61 99.72 90 bottom
R5773  470R2F-GP  [R402H16]  21.8 97.31 0 bottom
R5774  470R2F-GP  [R402H16]  21.8 95.61 180 bottom
R5775  470R2F-GP  [R402H16]  22.58 99.52 0 bottom
R5776  470R2F-GP  [R402H16]  22.58 97.82 180 bottom
R5777  470R2F-GP  [R402H16]  23.4 101.63 0 bottom
R5778  470R2F-GP  [R402H16]  23.4 100.05 180 bottom
R5781  150KR2F-L-GP  [R402H16]  16.18 107.93 180 bottom
R5782  100KR2J-1-GP  [R402H16]  14.15 113 0 bottom
R5804  4K99R2F-L-GP  [R402H16]  56.16 114.5 90 top
R5805  4K7R2J-2-GP  [R402H16]  54.44 115.65 180 bottom
R5807  4K7R2J-2-GP  [R402H16]  43.77 116.99 90 top
R5808  4K7R2J-2-GP  [R402H16]  43.77 116.21 90 top
R5809  4K7R2J-2-GP  [R402H16]  44.07 119.38 90 top
R5810  4K7R2J-2-GP  [R402H16]  43.97 118.62 90 top
R5811  4K7R2J-2-GP  [R402H16]  44 117.86 90 top
R5812  4K7R2J-2-GP  [R402H16]  56.82 116.51 135 bottom
R5813  4K7R2J-2-GP  [R402H16]  44.07 120.17 90 top
R5814  4K7R2J-2-GP  [R402H16]  44.96 121.11 270 top
R5815  4K7R2J-2-GP  [R402H16]  44.71 114.66 90 top
R5816  4K7R2J-2-GP  [R402H16]  53.01 113.13 270 bottom
R5817  2K2R2J-2-GP  [R402H16]  44.96 113.89 90 top
R5818  1MR2J-1-GP  [R402H16]  52.61 119.56 180 bottom
R5819  1MR2J-1-GP  [R402H16]  53.47 119.53 180 bottom
R5820  1MR2J-1-GP  [R402H16]  53.67 115.65 180 bottom
R5821  0R2F-1-GP  [R402H16]  55.2 115.65 180 bottom
R5822  100KR2J-1-GP  [R402H16]  57.86 120.19 0 top
R5823  100KR2J-1-GP  [R402H16]  57.86 118.59 180 top
R5824  0R2J-L-GP  [R402H15]  56.67 119.01 270 top
R5825  0R2J-L-GP  [R402H15]  56.67 119.8 270 top
R5826  0R2J-L-GP  [R402H15]  51.9 124.44 90 top
R5827  0R2J-L-GP  [R402H15]  50.31 124.44 270 top
R5828  0R2J-L-GP  [R402H15]  54.16 123.57 180 top
R5829  0R2J-L-GP  [R402H15]  54.16 121.99 0 top
R5830  0R2J-L-GP  [R402H15]  59.94 119.89 180 bottom
R5831  0R2J-L-GP  [R402H15]  59.15 119.89 180 bottom
R5832  0R2J-L-GP  [R402H15]  47.55 111.18 270 top
R5833  0R2J-L-GP  [R402H15]  45.98 111.18 90 top
R5834  2K2R2J-2-GP  [R402H16]  45.22 113.13 90 top
R5838  0R2J-L-GP  [R402H15]  49.48 111.71 90 top
R5839  0R2J-L-GP  [R402H15]  51.06 111.71 270 top
R5840  0R2J-L-GP  [R402H15]  50.71 124.03 0 top
R5841  0R2J-L-GP  [R402H15]  51.49 124.03 0 top
R5842  0R2J-L-GP  [R402H15]  53.75 123.16 270 top
R5843  0R2J-L-GP  [R402H15]  53.75 122.4 270 top
R5844  0R2J-L-GP  [R402H15]  61.45 117.12 0 top
R5845  0R2J-L-GP  [R402H15]  60.61 117.12 0 top
R5854  5D1R2J-1-GP  [R402H16]  46.38 113.11 180 top
R5855  5D1R2J-1-GP  [R402H16]  51.72 113.03 180 top
R5856  5D1R2J-1-GP  [R402H16]  52.48 113.03 180 top
R5857  5D1R2J-1-GP  [R402H16]  53.24 113.03 180 top
R5858  5D1R2J-1-GP  [R402H16]  54 113.03 180 top
R5859  5D1R2J-1-GP  [R402H16]  47.15 113.11 180 top
R5860  5D1R2J-1-GP  [R402H16]  49.89 113.64 180 top
R5861  5D1R2J-1-GP  [R402H16]  50.65 113.64 180 top
R6001  -  [0R0805-PAD]  157.51 36.37 180 top
R6002  0R0402-PAD-1-GP  [0R0402-PAD]  153.83 39.12 0 top
R6003  -  [0R0805-PAD]  189.25 33.43 180 top
R6004  0R0402-PAD-1-GP  [0R0402-PAD]  184.64 40.82 0 top
R6101  75KR2J-GP  [R402H16]  48.09 108.94 180 top
R6102  75KR2J-GP  [R402H16]  61.98 94.29 180 top
R6104  0R0402-PAD-1-GP  [0R0402-PAD]  31.78 97.25 90 top
R6105  0R0402-PAD-1-GP  [0R0402-PAD]  31.78 98.03 90 top
R6108  0R2J-L-GP  [R402H15]  42.61 104.88 180 top
R6109  0R2J-L-GP  [R402H15]  43.59 101.5 270 top
R6110  0R2J-L-GP  [R402H15]  48.59 107.75 270 top
R6114  10KR2J-3-GP  [R402H16]  45.14 104.83 0 top
R6115  10KR2J-3-GP  [R402H16]  43.39 104.88 0 top
R6117  33R2J-2-GP  [R402H16]  22.34 77.62 180 bottom
R6120  22R2J-2-GP  [R402H16]  40.06 100.43 225 top
R6121  71K5R2F-1-GP  [R402H16]  33.1 105 270 top
R6122  71K5R2F-1-GP  [R402H16]  36.1 105.06 90 top
R6123  22R2J-2-GP  [R402H16]  39.5 99.9 225 top
R6124  0R5J-5-GP  [R805H24]  46.41 104.54 0 top
R6125  0R5J-5-GP  [R805H24]  48.17 104.53 180 top
R6201  0R0402-PAD-1-GP  [0R0402-PAD]  205.49 62.92 90 top
R6202  0R2J-2-GP  [R402H16]  216.56 58.65 0 top
R6203  0R2J-2-GP  [R402H16]  215.8 58.65 0 top
R6301  0R0402-PAD-1-GP  [0R0402-PAD]  41.53 32.95 270 top
R6302  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  41.99 28.2 90 bottom
R6348  100KR2F-L1-GP  [R402H16]  28.78 24.74 180 top
R6349  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  41.99 29.47 90 bottom
R6403  10KR2J-3-GP  [R402H16]  61.34 40.06 90 bottom
R6404  1MR2F-GP  [R402H16]  40.77 78.03 0 top
R6405  330R2J-3-GP  [R402H16]  45.47 77.9 90 top
R6406  549R2F-GP  [R402H16]  12.25 129.62 0 bottom
R6407  499R2F-2-GP  [R402H16]  11.46 129.62 0 bottom
R6408  0R2J-2-GP  [R402H16]  23.96 78.79 270 bottom
R6409  0R2J-2-GP  [R402H16]  26.19 76.33 90 bottom
R6410  422R2F-2-GP  [R402H16]  211.89 56.72 90 top
R6411  10KR2J-3-GP  [R402H16]  30.1 22.66 90 top
R6412  0R2J-2-GP  [R402H16]  51.08 59.13 90 top
R6413  150R2F-1-GP  [R402H16]  40.77 79.81 180 top
R6414  330KR2F-L-GP  [R402H16]  50.57 66.96 90 top
R6415  10KR2J-3-GP  [R402H16]  31.52 20.4 0 top
R6502  0R2J-2-GP  [R402H16]  99.7 31.29 90 top
R6503  100R3J-4-GP  [R603H22]  96.14 31.04 270 bottom
R6504  20KR2F-L-GP  [R402H16]  93.65 31.04 90 bottom
R6505  0R2J-2-GP  [R402H16]  105.03 35.74 0 top
R6506  0R2J-2-GP  [R402H16]  104.27 35.74 0 top
R6507  51KR2J-1-GP  [R402H16]  80.6 34.77 270 bottom
R6508  100KR2J-1-GP  [R402H16]  78.95 36.5 90 bottom
R6511  10KR2J-3-GP  [R402H16]  103.89 36.76 90 bottom
R6513  1KR2J-1-GP  [R402H16]  100.51 32.74 180 bottom
R6601  0R2J-2-GP  [R402H16]  201.78 37.19 90 top
R6602  0R2J-2-GP  [R402H16]  125.91 85.27 180 bottom
R6604  0R2J-2-GP  [R402H16]  205.41 39.37 90 bottom
R6605  0R2J-2-GP  [R402H16]  205.41 40.13 90 bottom
R6606  0R2J-2-GP  [R402H16]  205.41 40.93 90 bottom
R6607  0R2J-2-GP  [R402H16]  205.41 41.69 90 bottom
R6608  0R2J-2-GP  [R402H16]  125.91 83.69 0 bottom
R6609  10KR2J-3-GP  [R402H16]  127.08 83.29 90 bottom
R6610  0R2J-2-GP  [R402H16]  40.77 76.43 0 top
R6611  10KR2J-3-GP  [R402H16]  156.72 106.91 180 top
R6801  0R2J-L-GP  [R402H15]  33.2 45.11 180 top
R6802  0R2J-L-GP  [R402H15]  30.99 44.88 180 top
R6803  0R2J-L-GP  [R402H15]  27.44 45.77 90 top
R6804  4K7R2F-GP  [R402H16]  85.91 35.61 180 top
R6877  1KR2J-1-GP  [R402H16]  85.14 35.61 180 top
R6878  0R2J-L-GP  [R402H15]  16.56 39.98 180 top
R7004  -  [0R0402-PAD]  135.36 95.4 0 top
R7006  10KR2J-3-GP  [R402H16]  133.56 93.65 90 top
R7007  -  [0R0402-PAD]  133.66 95.51 270 top
R7010  100KR2J-1-GP  [R402H16]  136.58 96.42 90 top
R7011  1MR2J-1-GP  [R402H16]  137.44 91.89 90 top
R7014  100KR2J-1-GP  [R402H16]  139.46 92.38 180 top
R7101  100KR2J-4-GP  [R402H15]  26.47 113.77 0 top
R7102  100KR2J-4-GP  [R402H15]  26.5 112.09 180 top
R7103  0R2J-2-GP  [R402H16]  27.66 112.57 270 top
R7104  0R2J-2-GP  [R402H16]  27.66 113.34 270 top
R7114  -  [0R0402-PAD]  26.11 109.27 90 top
R7115  0R2J-2-GP  [R402H16]  13.62 116.59 90 bottom
R7116  -  [0R0402-PAD]  26.11 110.08 90 top
R7117  0R2J-2-GP  [R402H16]  13.62 117.35 90 bottom
R7118  0R2J-2-GP  [R402H16]  26.12 110.87 90 top
R7119  0R2J-2-GP  [R402H16]  13.62 115.04 90 bottom
R7120  0R2J-2-GP  [R402H16]  13.62 115.8 90 bottom
R7122  0R2J-2-GP  [R402H16]  13.34 128.42 90 bottom
R7123  0R2J-2-GP  [R402H16]  13.34 127.66 90 bottom
R7124  0R2J-2-GP  [R402H16]  13.34 126.87 90 bottom
R7125  0R2J-2-GP  [R402H16]  13.34 126.11 90 bottom
R7126  -  [0R0402-PAD]  34.7 121.36 0 top
R7127  -  [0R0402-PAD]  33.18 121.49 0 top
R7128  -  [0R0402-PAD]  35.92 120.74 270 top
R7129  -  [0R0402-PAD]  31.8 120.71 90 top
R7130  -  [0R0402-PAD]  35.92 119.97 270 top
R7131  0R2J-2-GP  [R402H16]  30.01 118.59 0 top
R7132  0R2J-2-GP  [R402H16]  30.02 116.99 180 top
R7133  0R2J-2-GP  [R402H16]  31.59 114.38 0 top
R7134  0R2J-2-GP  [R402H16]  32.37 114.38 0 top
R7140  1KR2J-1-GP  [R402H16]  18.65 105.28 180 bottom
R7141  1KR2J-1-GP  [R402H16]  20.81 105.41 270 bottom
R7142  1KR2J-1-GP  [R402H16]  18.65 103.68 0 bottom
R7143  1KR2J-1-GP  [R402H16]  20.78 104.52 270 bottom
R7144  20KR2J-L3-GP  [R402H16]  20.15 103.2 90 bottom
R7145  1KR2J-1-GP  [R402H16]  24.31 103.2 0 bottom
R7146  1KR2J-1-GP  [R402H16]  23.4 104.5 90 bottom
R7147  1KR2J-1-GP  [R402H16]  19.82 100.66 180 top
R7152  1KR2J-1-GP  [R402H16]  20.65 100.33 180 top
R7153  0R2J-L-GP  [R402H15]  24.51 100.38 270 top
R7154  0R2J-L-GP  [R402H15]  24.51 101.14 270 top
R7155  0R2J-L-GP  [R402H15]  21.47 100.76 180 top
R7156  0R2J-L-GP  [R402H15]  22.23 100.76 180 top
R7170  1KR2J-1-GP  [R402H16]  20.15 102.44 90 bottom
R7171  1KR2J-1-GP  [R402H16]  25.07 103.2 0 bottom
R7172  1KR2J-1-GP  [R402H16]  23.4 105.34 90 bottom
R7173  1KR2J-1-GP  [R402H16]  23.42 106.22 90 bottom
R7174  1KR2J-1-GP  [R402H16]  23.4 107.8 90 bottom
R7175  0R2J-2-GP  [R402H16]  19.43 101.02 90 bottom
R7176  0R2J-2-GP  [R402H16]  16.94 109.5 0 bottom
R7177  5D1R2J-1-GP  [R402H16]  25.76 102.97 270 top
R7178  5D1R2J-1-GP  [R402H16]  25.76 103.73 270 top
R7179  5D1R2J-1-GP  [R402H16]  25.73 104.52 270 top
R7180  5D1R2J-1-GP  [R402H16]  25.73 105.28 270 top
R7181  5D1R2J-1-GP  [R402H16]  25.75 106.08 270 top
R7182  5D1R2J-1-GP  [R402H16]  25.75 106.85 270 top
R7183  5D1R2J-1-GP  [R402H16]  25.73 107.65 270 top
R7184  5D1R2J-1-GP  [R402H16]  25.73 108.43 270 top
R7185  220KR2F-GP  [R402H16]  11.38 111.43 90 top
R7186  220KR2F-GP  [R402H16]  16.54 109.25 180 top
R7187  220KR2F-GP  [R402H16]  16.54 107.67 0 top
R7188  220KR2F-GP  [R402H16]  9.81 111.43 270 top
R7189  10KR2J-3-GP  [R402H16]  18.65 108.36 0 bottom
R7190  4K7R2J-2-GP  [R402H16]  18.77 106.55 90 bottom
R7201  10KR2F-2-GP  [R402H16]  45.09 107.8 270 top
R7202  10KR2F-2-GP  [R402H16]  38.28 115.36 270 top
R7203  -  [0R0402-PAD]  49 124.05 0 top
R7204  -  [0R0402-PAD]  52.84 126.54 270 top
R7205  100KR2F-L1-GP  [R402H16]  44.96 124.3 90 top
R7206  -  [0R0402-PAD]  38.13 113.44 270 top
R7210  -  [0R0402-PAD]  54.11 125.78 0 top
R7211  4K7R2J-2-GP  [R402H16]  42.7 114.23 180 top
R7212  30KR2J-4-GP  [R402H16]  43.89 106.48 180 top
R7213  1KR2F-3-GP  [R402H16]  46.74 109.32 0 top
R7214  10KR2F-2-GP  [R402H16]  43.49 107.65 270 top
R7215  2K2R2J-2-GP  [R402H16]  41.91 114.23 0 top
R7216  10KR2J-3-GP  [R402H16]  56.67 135.21 90 top
R7217  909KR2F-GP  [R402H16]  48.59 128.96 180 top
R7218  301KR2F-1-GP  [R402H16]  55.73 132.56 0 top
R7219  10KR2F-2-GP  [R402H16]  36.99 111.86 0 top
R7330  2MR2F-GP  [R402H16]  17.45 110.95 0 top
R7331  2MR2F-GP  [R402H16]  17.45 109.37 180 top
R7332  0R2J-L-GP  [R402H15]  9.73 122.3 180 top
R7333  0R2J-L-GP  [R402H15]  10.49 122.3 180 top
R7334  0R2J-L-GP  [R402H15]  11.53 120.93 270 bottom
R7335  0R2J-L-GP  [R402H15]  11.53 120.17 270 bottom
R7401  200KR2F-L-GP  [R402H16]  28.12 111.38 180 top
R7402  10KR2F-2-GP  [R402H16]  39.98 119.97 0 top
R7403  -  [0R0402-PAD]  33.96 123.12 270 top
R7404  1MR2F-GP  [R402H16]  35.94 121.85 270 top
R7405  100KR2J-1-GP  [R402H16]  40.75 120.35 180 top
R7406  100KR2F-L1-GP  [R402H16]  31.47 108.31 0 top
R7407  100KR2J-1-GP  [R402H16]  34.33 124.31 180 top
R7408  100KR2F-L1-GP  [R402H16]  30.89 107.13 270 top
R7410  150R6J-1-GP  [R1206H26]  46.61 128.73 180 top
R7414  47KR2J-2-GP  [R402H16]  42.04 119.61 180 top
R7415  100KR2J-1-GP  [R402H16]  34.22 110.07 270 top
R7418  14K3R2F-GP  [R402H16]  42.85 119.89 0 top
R7422  1MR2F-GP  [R402H16]  31.4 111.05 270 top
R7423  100KR2F-L1-GP  [R402H16]  27.44 115.67 180 bottom
R7424  100KR2F-L1-GP  [R402H16]  38.39 120.55 180 top
R7425  100KR2F-L1-GP  [R402H16]  24.59 109.42 0 bottom
R7426  100KR2F-L1-GP  [R402H16]  24.59 107.85 180 bottom
R7427  100KR2F-L1-GP  [R402H16]  30.71 115.65 270 top
R7428  100KR2F-L1-GP  [R402H16]  30.05 113.59 270 top
R7429  200KR2F-L-GP  [R402H16]  26.55 104.14 270 bottom
R7430  200KR2F-L-GP  [R402H16]  27.55 114.05 0 bottom
R7431  200KR2F-L-GP  [R402H16]  26.72 112.57 135 bottom
R7432  1MR2F-GP  [R402H16]  198.48 54.43 180 top
R7433  100KR2F-L1-GP  [R402H16]  54.87 125.78 0 top
R7601  2K49R2F-GP  [R402H16]  128.45 148.18 45 bottom
R7602  10KR2F-2-GP  [R402H16]  121.11 138.52 45 bottom
R7603  10KR2J-3-GP  [R402H16]  134.32 97.41 0 bottom
R7604  200R2F-L-GP  [R402H16]  143.44 152.57 270 bottom
R7606  100KR2F-L1-GP  [R402H16]  134.56 96.21 90 bottom
R7613  0R2J-2-GP  [R402H16]  137.4 101.22 180 bottom
R7614  10KR2J-3-GP  [R402H16]  138.2 101.22 0 bottom
R7616  0R3J-0-U-GP  [R603H22]  125.8 132.15 45 top
R7803  60D4R2F-GP  [R402H16]  151.08 117.37 90 top
R7804  60D4R2F-GP  [R402H16]  149 116.71 0 top
R7805  40D2R2F-GP  [R402H16]  151.08 118.14 90 top
R7806  60D4R2F-GP  [R402H16]  149.69 119.86 90 top
R7807  40D2R2F-GP  [R402H16]  150.88 119.31 180 top
R7816  10KR2F-2-GP  [R402H16]  160.91 129.85 270 bottom
R7818  10KR2J-3-GP  [R402H16]  128.5 118.52 135 bottom
R7820  10KR2F-2-GP  [R402H16]  159.32 129.67 270 bottom
R7821  10KR2F-2-GP  [R402H16]  159.64 137.47 270 bottom
R7824  10KR2F-2-GP  [R402H16]  160.91 136.7 270 bottom
R7901  10KR2J-3-GP  [R402H16]  140.49 120.47 225 bottom
R7902  10KR2J-3-GP  [R402H16]  148.49 115.77 270 bottom
R7903  1MR2J-1-GP  [R402H16]  155.22 110.55 180 bottom
R7904  1K3R2J-GP  [R402H16]  154.34 109.69 0 bottom
R7905  100KR2J-1-GP  [R402H16]  148.49 114.25 270 bottom
R7907  40K2R2F-GP  [R402H16]  136.12 122.28 315 top
R7908  100KR2F-L1-GP  [R402H16]  130 115.24 135 bottom
R7909  100KR2F-L1-GP  [R402H16]  127.99 115.42 315 bottom
R7910  100KR2J-1-GP  [R402H16]  158.37 113.56 90 bottom
R7911  100KR2F-L1-GP  [R402H16]  126.9 116.08 180 bottom
R7912  0R2J-2-GP  [R402H16]  140.65 104.73 180 bottom
R7913  0R2J-2-GP  [R402H16]  136.25 113.56 180 bottom
R7914  100KR2F-L1-GP  [R402H16]  131.33 113.92 315 bottom
R7915  100KR2F-L1-GP  [R402H16]  131.86 113.36 135 bottom
R7916  0R2J-2-GP  [R402H16]  133.51 107.01 180 bottom
R7917  10KR2J-3-GP  [R402H16]  148.49 115.01 90 bottom
R7918  100KR2F-L1-GP  [R402H16]  148.82 122.09 90 bottom
R7919  49K9R2F-L-GP  [R402H16]  128.63 114.96 315 bottom
R7920  100KR2F-L1-GP  [R402H16]  148.49 118.94 90 bottom
R7921  100KR2F-L1-GP  [R402H16]  148.49 119.74 270 bottom
R7922  100KR2J-1-GP  [R402H16]  138.27 102.91 90 bottom
R7923  0R2J-2-GP  [R402H16]  141.42 104.72 0 bottom
R7924  100KR2F-L1-GP  [R402H16]  148.49 120.52 270 bottom
R7926  100KR2F-L1-GP  [R402H16]  125.73 115.75 270 bottom
R7927  10KR2J-3-GP  [R402H16]  131.7 100.69 180 top
R7929  100KR2F-L1-GP  [R402H16]  134.95 113.03 315 bottom
R7931  10KR2J-3-GP  [R402H16]  135.53 103.48 270 bottom
R7932  100KR2F-L1-GP  [R402H16]  148.82 122.99 270 bottom
R7933  10KR2J-3-GP  [R402H16]  134.27 110.82 315 bottom
R7935  100KR2F-L1-GP  [R402H16]  148.82 121.31 90 bottom
R7936  0R2J-2-GP  [R402H16]  134.85 110.31 315 bottom
R7939  100KR2F-L1-GP  [R402H16]  132.41 112.8 135 bottom
R7943  0R2J-2-GP  [R402H16]  129.62 128.53 225 top
R7944  10KR2J-3-GP  [R402H16]  117.1 127.08 270 bottom
R7945  0R2J-2-GP  [R402H16]  132.57 111.56 315 bottom
R7946  0R2J-2-GP  [R402H16]  156.24 112.9 270 bottom
R7947  0R2J-2-GP  [R402H16]  148.5 118.15 270 bottom
R7948  10KR2J-3-GP  [R402H16]  128.47 104.52 90 bottom
R7949  10KR2J-3-GP  [R402H16]  134.34 103.89 180 bottom
R7952  10KR2J-3-GP  [R402H16]  132.43 103.53 180 bottom
R7953  10KR2J-3-GP  [R402H16]  128.48 103.73 270 bottom
R7959  0R2J-2-GP  [R402H16]  133.28 105.84 90 bottom
R7960  0R2J-2-GP  [R402H16]  134.27 107.01 0 bottom
R7961  0R2J-2-GP  [R402H16]  135.03 106.78 0 bottom
R7963  0R2J-2-GP  [R402H16]  136.25 111.96 180 bottom
R7964  0R2J-2-GP  [R402H16]  133.2 105.08 90 bottom
R7965  0R2J-2-GP  [R402H16]  136.07 109.17 135 bottom
R7966  0R2J-2-GP  [R402H16]  135.51 109.73 135 bottom
R7973  0R2J-2-GP  [R402H16]  136.68 108.41 135 bottom
R7974  0R2J-2-GP  [R402H16]  138.28 103.78 90 bottom
R7975  10KR2J-3-GP  [R402H16]  131.07 100.99 90 bottom
R7976  100KR2F-L1-GP  [R402H16]  133.78 111.43 315 bottom
R7977  100KR2F-L1-GP  [R402H16]  125.73 114.99 90 bottom
R7978  100KR2F-L1-GP  [R402H16]  129.59 113.03 225 bottom
R8001  0R2J-2-GP  [R402H16]  125.05 130.13 45 top
R8002  0R2J-2-GP  [R402H16]  125.61 130.68 45 top
R8003  0R2J-2-GP  [R402H16]  138 120.83 180 top
R8101  549R2F-GP  [R402H16]  165.36 115.11 90 bottom
R8102  931R2F-1-GP  [R402H16]  162.61 115.14 0 bottom
R8103  1K33R2F-GP  [R402H16]  163.4 115.14 180 bottom
R8104  549R2F-GP  [R402H16]  161.22 150.8 90 bottom
R8105  931R2F-1-GP  [R402H16]  165.89 113.01 270 bottom
R8106  1K33R2F-GP  [R402H16]  159.92 152.6 90 bottom
R8107  121R2F-GP  [R402H16]  159.64 115.5 90 bottom
R8108  121R2F-GP  [R402H16]  159.64 150.8 90 bottom
R8109  1KR2J-1-GP  [R402H16]  152.28 120.83 270 bottom
R8110  1KR2J-1-GP  [R402H16]  151.26 145.85 270 bottom
R8111  1KR2J-1-GP  [R402H16]  160.86 137.59 90 top
R8112  1KR2J-1-GP  [R402H16]  160.71 129.08 270 top
R8113  40D2R2F-GP  [R402H16]  152.28 121.21 90 top
R8114  40D2R2F-GP  [R402H16]  152.28 120.45 90 top
R8115  40D2R2F-GP  [R402H16]  150.75 144.32 270 bottom
R8116  40D2R2F-GP  [R402H16]  150.75 145.09 270 bottom
R8601  0R3J-0-U-GP  [R603H22]  163.35 108.48 90 top
R8602  0R3J-0-U-GP  [R603H22]  166.5 107.01 270 bottom
R8604  1MR2J-1-GP  [R402H16]  107.95 153.67 0 bottom
R8605  0R2J-2-GP  [R402H16]  128.83 134.62 225 top
R8606  0R2J-2-GP  [R402H16]  131.04 149.18 315 bottom
R8607  0R2J-2-GP  [R402H16]  128.26 134.03 225 top
R8608  0R2J-2-GP  [R402H16]  127.71 133.48 225 top
R8701  100KR2J-1-GP  [R402H16]  104.3 146.51 180 bottom
R8702  22R2J-L1-GP  [R402H16]  106.51 145.21 270 bottom
R8703  100KR2J-1-GP  [R402H16]  103.23 142.74 270 top
R8704  100R2J-2-GP  [R402H14]  102.44 147.05 270 top
R8705  100KR2J-1-GP  [R402H16]  105.78 152.17 180 top
R8706  100R2J-2-GP  [R402H14]  105.97 143.26 180 top
R8707  100R2J-2-GP  [R402H14]  102.39 146.83 90 bottom
R8708  100KR2J-1-GP  [R402H16]  104.3 144.93 0 bottom
R8709  100R2J-2-GP  [R402H14]  110.37 151.18 180 top
R8710  100KR2J-1-GP  [R402H16]  103.56 142.32 180 bottom
R8801  4K7R2J-2-GP  [R402H16]  99.33 147.07 270 top
R8803  75KR2J-GP  [R402H16]  101.93 142.8 180 bottom
R8806  3K3R2F-2-GP  [R402H16]  107.8 141.38 90 top
R8807  82KR2J-GP  [R402H16]  107.19 153.67 180 bottom
R8808  -  [0R0402-PAD]  97.62 144.2 90 top
R8809  -  [0R0402-PAD]  99.57 146.36 90 bottom
R8810  10KR2F-L1-GP  [R402H15]  95.84 148.69 270 top
R8811  -  [0R0402-PAD]  99.9 146.28 270 top
R9101  0R2J-2-GP  [R402H16]  164.21 84.38 90 top
R9118  2K2R2F-GP  [R402H16]  160.2 79.96 0 top
R9119  10KR2J-3-GP  [R402H16]  159.88 75.76 270 top
R9121  0R2J-2-GP  [R402H16]  167.62 80.62 45 top
R9130  -  [0R0402-PAD]  162.06 76.08 180 top
R9132  49D9R2F-GP  [R402H16]  165.87 77.06 180 top
R9133  49D9R2F-GP  [R402H16]  164.29 76.58 270 top
R9138  49D9R2F-GP  [R402H16]  161.24 76.08 180 top
R9148  10KR2J-3-GP  [R402H16]  162.99 76.12 180 top
R9149  0R2J-2-GP  [R402H16]  165.1 78.79 180 bottom
R9150  0R2J-2-GP  [R402H16]  161.55 80.42 180 bottom
R9151  0R2J-2-GP  [R402H16]  159.9 74.97 270 top
R9152  0R2J-2-GP  [R402H16]  160.47 76.96 180 top
R9201  1KR2J-1-GP  [R402H16]  203.63 65.41 270 top
R9209  -  [0R0402-PAD]  205.18 56.49 90 bottom
R9210  -  [0R0402-PAD]  205.18 55.73 90 bottom
R9211  0R2J-2-GP  [R402H16]  222.35 64.69 90 top
R9212  100KR2J-1-GP  [R402H16]  166.8 70.99 0 top
RJ1  RJ45-8P-291-GP  [2RJ3076-078211F]  2.75 76.65 90 bottom
RN401  SRN2K2J-4-GP  [ARES8-CN24-UH20]  126.45 103.94 270 bottom
RN1201  SRN1KJ-7-GP  [SMD-ARES4H18]  71.05 42.22 180 top
RN1301  SRN1KJ-7-GP  [SMD-ARES4H18]  148.85 42.4 90 top
RN1601  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  126.44 106.35 270 bottom
RN1602  SRN0J-6-GP  [SMD-ARES4H20]  126.44 108.33 90 bottom
RN1703  SRN10KJ-5-GP  [ARES2H18]  156.48 67.67 0 top
RN1704  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  141.28 70.66 180 top
RN1801  SRN20KJ-1-GP  [SMD-ARES4H20]  168.21 68.29 180 top
RN1806  SRN15J-GP  [ARES8-CN24-MUH20]  105.49 75.87 180 top
RN1807  SRN2K2J-4-GP  [ARES8-CN24-UH20]  122.27 96.3 270 bottom
RN1810  SRN10KJ-5-GP  [ARES2H18]  128.93 96.36 270 bottom
RN1811  SRN2K2J-1-GP  [ARES2H16]  151.76 109.68 270 bottom
RN2001  SRN20KJ-1-GP  [SMD-ARES4H20]  115.28 95.1 180 top
RN2402  SRN4K7J-8-GP  [SMD-ARES4H18]  21.31 69.6 270 top
RN2403  SRN100KJ-5-GP  [ARES8-CN24H20]  61.65 29.24 0 top
RN2404  SRN100KJ-5-GP  [ARES8-CN24H20]  59.08 29.26 0 top
RN2405  SRN100KJ-6-GP  [SMD-ARES4]  21.59 72.98 90 top
RN2407  SRN100KJ-6-GP  [SMD-ARES4]  63.73 29.26 0 top
RN2409  SRN100KJ-5-GP  [ARES8-CN24H20]  65.76 29.26 0 top
RN2410  SRN100KJ-5-GP  [ARES8-CN24H20]  70.87 29.26 0 top
RN2411  SRN100KJ-6-GP  [SMD-ARES4]  74.22 29.34 0 top
RN2412  SRN100KJ-5-GP  [ARES8-CN24H20]  68.3 29.26 0 top
RN2413  SRN2K2J-1-GP  [ARES2H16]  34.22 114.81 0 top
RN2601  SRN10KJ-5-GP  [ARES2H18]  161.29 82.73 180 bottom
RN2901  SRN2K2J-1-GP  [ARES2H16]  21.21 16.66 270 top
RN3201  SRN75J-1-GP  [ARES8-CN24H22]  26.17 86.29 0 bottom
RN4302  SRN100J-4-GP  [ARES8-CN24H20]  138.78 36.7 270 top
RN5502  SRN100KJ-5-GP  [ARES8-CN24H20]  222.38 37.01 180 top
RN5503  SRN100J-4-GP  [ARES8-CN24H20]  222.25 39.04 0 top
RN5504  SRN33J-5-GP-U  [SMD-ARES4H18]  212.75 40.92 180 top
RN5505  SRN33J-5-GP-U  [SMD-ARES4H18]  221.57 42.39 180 top
RN6401  SRN100J-3-GP  [SMD-ARES4H18]  209.6 61.75 180 top
RN6501  SRN10KJ-5-GP  [ARES2H18]  107.09 29.41 0 top
RN6502  SRN33J-5-GP-U  [SMD-ARES4H18]  109.73 35.74 180 top
RN6503  SRN2K2J-1-GP  [ARES2H16]  105.13 29.08 0 top
RN7201  SRN2K2J-1-GP  [ARES2H16]  39.88 114.78 180 top
RN7202  SRN2K2J-1-GP  [ARES2H16]  36.2 109.6 270 top
RN7701  SRN1K8J-GP  [ARES2H18]  138.76 106.61 0 bottom
RN7901  SRN4K7J-8-GP  [SMD-ARES4H18]  148.55 111.7 0 bottom
RN7904  SRN2K2J-1-GP  [ARES2H16]  141.79 106.68 180 bottom
RN7905  SRN2K2J-1-GP  [ARES2H16]  140.26 106.55 180 bottom
RN7910  SRN10KJ-5-GP  [ARES2H18]  137.26 106.61 0 bottom
SPK1  ACES-CON4-29-GP  [50224-0040N-001]  9.7 1.8 180 bottom
SPR3  SPRING-63-GP  [SPR5630H142]  25.21 43.68 270 bottom
SPR4  SPRING-63-GP  [SPR5630H142]  80.97 39.83 0 bottom
SSD1  SKT-NGFF75P-202-GP-U  [NFSM0-S6701-TSH4-U]  27.2 27.3 180 bottom
TP1  ACES-CON8-66-GP  [51574-0084N-W01]  106.7 32.3 180 bottom
TP301  TPAD14-OP-GP  [TPAD14-OP]  81.16 109.27 180 bottom
TP302  TPAD14-OP-GP  [TPAD14-OP]  74.3 110.54 180 bottom
TP303  TPAD14-OP-GP  [TPAD14-OP]  74.3 109.27 180 bottom
TP307  TPAD14-OP-GP  [TPAD14-OP]  75.57 110.54 180 bottom
TP308  TPAD14-OP-GP  [TPAD14-OP]  75.57 109.27 180 bottom
TP402  TPAD14-OP-GP  [TPAD14-OP]  114.38 104.55 0 top
TP618  TPAD14-OP-GP  [TPAD14-OP]  78.11 109.65 180 bottom
TP619  TPAD14-OP-GP  [TPAD14-OP]  71.33 105.16 0 top
TP620  TPAD14-OP-GP  [TPAD14-OP]  115.01 88.47 0 top
TP1702  TPAD14-OP-GP  [TPAD14-OP]  103.05 88.11 0 top
TP1705  TPAD14-OP-GP  [TPAD14-OP]  105.24 78.28 180 bottom
TP1706  TPAD14-OP-GP  [TPAD14-OP]  103.97 86.84 0 top
TP1708  TPAD14-OP-GP  [TPAD14-OP]  107.52 81.48 180 bottom
TP1807  TPAD14-OP-GP  [TPAD14-OP]  90.82 110.54 180 bottom
TP1808  TPAD14-OP-GP  [TPAD14-OP]  90.82 109.3 180 bottom
TP1901  TPAD14-OP-GP  [TPAD14-OP]  100.03 81.48 180 bottom
TP2101  TPAD14-OP-GP  [TPAD14-OP]  118.34 92.89 180 bottom
TP2102  TPAD14-OP-GP  [TPAD14-OP]  110.32 95.4 0 top
TP2103  TPAD14-OP-GP  [TPAD14-OP]  108.84 95.43 0 top
TP2201  TPAD14-OP-GP  [TPAD14-OP]  106.78 80.19 180 bottom
TP2202  TPAD14-OP-GP  [TPAD14-OP]  106.25 81.31 180 bottom
TP4401  TPAD28-2-GP  [TPAD28]  199.24 52.63 0 top
TP4411  TPAD14-OP-GP  [TPAD14-OP]  196.09 39.55 90 top
TP4601  TPAD14-OP-GP  [TPAD14-OP]  81.89 153.47 0 bottom
TP6001  TPAD14-OP-GP  [TPAD14-OP]  190.73 33.3 0 top
TP6201  TPAD14-OP-GP  [TPAD14-OP]  216.44 55.63 0 top
TP7201  TPAD14-OP-GP  [TPAD14-OP]  44.53 108.94 0 top
TP7701  TPAD14-OP-GP  [TPAD14-OP]  116.82 129.31 180 bottom
TP7901  TPAD14-OP-GP  [TPAD14-OP]  120.86 133.61 315 top
TP7902  TPAD14-OP-GP  [TPAD14-OP]  121.29 132.46 135 top
TP7903  TPAD14-OP-GP  [TPAD14-OP]  117.91 128.22 180 bottom
TP7905  TPAD14-OP-GP  [TPAD14-OP]  122.18 134.29 315 top
TP9101  TPAD14-OP-GP  [TPAD14-OP]  158.78 83.14 0 top
TP9102  TPAD14-OP-GP  [TPAD14-OP]  167.01 82.98 135 top
TP9103  TPAD14-OP-GP  [TPAD14-OP]  159.97 83.44 0 top
TP9104  TPAD14-OP-GP  [TPAD14-OP]  160.73 84.43 225 top
TP9106  TPAD14-OP-GP  [TPAD14-OP]  76.84 110.54 180 bottom
TP9107  TPAD14-OP-GP  [TPAD14-OP]  76.84 109.27 180 bottom
U2401  MEC1416-NU-D0-GP  [TQFP128-2H48]  31.35 66.29 90 top
U2402  U74LVC1G08G-AL5-R-GP-U  [SC70-5-1H44]  44.86 53.87 0 top
U2502  G524B1T11U-GP  [SOT-23-5H58]  156.42 95.91 0 bottom
U2601  NCT7718W-GP  [MSOP8-1H44]  123.7 116.18 225 top
U3101  RTL8111H-CG-1-GP  [QFN32J4-G2D85H36]  46.09 83.54 90 top
U3502  SY6288DAAC-GP  [SOT-23-5H56]  18.19 40.44 90 bottom
U3601  TPS2544RTER-GP  [QFN16-G1D8-UH32]  20.76 51.69 0 top
U4001  G2898KD1U-GP  [DFN14J32-G255D95H32]  46.59 132.48 270 top
U4002  G5027RD1D-GP-U  [DFN8F3-G2517H32]  107.92 122.66 180 top
U4003  G5027RD1D-GP-U  [DFN8F3-G2517H32]  98.5 73.48 90 top
U4004  G2898KD1U-GP  [DFN14J32-G255D95H32]  59.59 37.85 270 bottom
U4006  G5027RD1D-GP-U  [DFN8F3-G2517H32]  113.24 116.89 90 top
U4007  TC7SZ08FU-LJ-CT-GP  [SC70-5H44]  89.71 40.2 270 bottom
U4302  S-1004NA23I-M5T1U-GP  [SOT-23-5H52]  39.62 117.44 270 top
U5501  AP22811AW5-7-GP  [SOT-23-5H56]  210.67 51.12 0 bottom
U5503  G2898KD1U-GP  [DFN14J32-G255D95H32]  157.49 105.39 270 bottom
U5702  APL3517-AI-TRG-GP  [SOT23-2D8-312H58]  17.2 101.96 90 bottom
U5802  PS8338BQFN60GTR-A1-GP  [QFN60J9050-G7131H32]  50.7 117.83 180 top
U6101  G517F1T12U-GP  [SOT-23-5H58]  58.75 94.23 0 bottom
U7001  LNG2DMTR-GP  [LGA12G2H40]  134.11 94.55 270 bottom
U7101  TUSB546A-DCIRNQR-GP  [QFN40J4060-G2848H32]  22 105.79 180 top
U7102  TS3DS10224RUKR-GP  [QFN20J3-G1D8H32]  33.04 118.39 180 top
U7201  CYPD4126-24LQXIT-GP  [QFN24-G2D8-UH24]  40.58 110.41 270 top
U7202  AP2151FMG-7-GP  [DFN6G1820-G1511-UH24]  47.16 125.47 90 top
U7203  TPS70933DRVR-GP-U  [DFN6F2-G1711-UH32]  50.39 128.92 270 top
U7302  U74LVC1G08G-AL5-R-GP-U  [SC70-5-1H44]  137.35 99.1 90 bottom
U7403  NX5P3363UKZ-1-GP  [CSP16G2D2H24]  42.4 123.32 270 top
U7418  AON7403-GP-U  [PPAK-8P-3232H36]  37.39 124.16 270 top
U7419  NX20P5090UK-GP  [CSP15G154256H24]  39.78 123.07 180 top
U7601  U74LVC1G08G-AL5-R-GP-U  [SC70-5-1H44]  136.92 96.45 270 bottom
U7602  U74LVC1G08G-AL5-R-GP-U  [SC70-5-1H44]  134.35 101.78 270 bottom
U8601  G2898KD1U-GP  [DFN14J32-G255D95H32]  164.9 109.37 90 bottom
U8801  U74LVC1G08G-AL5-R-GP-U  [SC70-5-1H44]  96.33 145.94 90 top
U8802  74LVC1G32GW-1GP  [SC70-5H44]  98.69 141.25 90 top
U8803  74LVC1G32GW-1GP  [SC70-5H44]  105.95 146.46 0 top
U8804  U74LVC1G08G-AL5-R-GP-U  [SC70-5-1H44]  95.76 151.07 0 top
U9103  ST33HTPH2032AHC1-GP  [QFN32G5-G3D75-UH40]  163.49 80.9 0 top
USB1  SKT-USB13-428-GP-U  [SKT-USB13-160146-4-U]  5.44 55.65 90 bottom
USB2  SKT-USB13-428-GP-U  [SKT-USB13-160146-4-U]  5.44 31 90 bottom
VGABD1  ACES-CON20-37-GP-U  [50406-02071-W01]  199.7 60.8 180 bottom
VRAM1  H5GC4H24AJR-T2C-GP  [BGA170D1214H48]  160.4 122.63 270 bottom
VRAM4  H5GC4H24AJR-T2C-GP  [BGA170D1214H48]  160.4 144.13 90 bottom
WLAN1  SKT-MINI67P-26-GP  [40-42064-067212HF]  40.2 102.8 180 bottom
WWAN1  KYO-CON34-GP  [04-6809-634-310-846]  220.2 53.8 90 top
X1801  XTAL-24MHZ-135-GP  [S-OSC3-2016H28]  118.88 117.25 180 bottom
X1802  XTAL-32D768KHZ-98-GP  [SMD49-12H34]  122.15 75.78 180 top
X2401  XTAL-32D768KHZ-98-GP  [SMD49-12H34]  25.38 78.28 270 top
X3101  XTAL-25MHZ-182-GP  [OSC-3225-4P-4H36]  45.54 88.9 180 top
X7901  XTAL-27MHZ-85-GP-U  [OSC-3225-4P-4H30]  157.18 110.15 270 bottom
XF3201  XFORM-12P-25-GP  [XFORM12A127096H81]  33.28 84.63 270 top
XF3202  XFORM-12P-25-GP  [XFORM12A127096H81]  33.28 84.63 90 bottom

## Library data of the parts
AFTP2601-AFTP2604 AFTP2901-AFTP2904 AFTP3201 AFTP3202 AFTP3204-AFTP3209 AFTP3502 AFTP3503 AFTP3507 AFTP3508 AFTP4302-AFTP4304 AFTP4306 AFTP4307 AFTP4309-AFTP4313 AFTP4315 AFTP4401-AFTP4408 AFTP4501 AFTP4502 AFTP4601-AFTP4606 AFTP5001 AFTP5501-AFTP5506 AFTP5509-AFTP5514 AFTP5517 AFTP5521-AFTP5523 AFTP5525 AFTP5601 AFTP5602 AFTP6001-AFTP6006 AFTP6108-AFTP6115 AFTP6401 AFTP6403 AFTP6404 AFTP6407 AFTP6408 AFTP6501 AFTP6524-AFTP6531 AFTP6537 AFTP6541-AFTP6567 AFTP6609-AFTP6611 AFTP6613-AFTP6615 AFTP6801-AFTP6803 AFTP7101 AFTP7102 AFTP7301-AFTP7304 AFTP9201 AFTP9204 = AFTE14P-75: tolerance: ZZ.AFT14.101
AFTP6402 TP301-TP303 TP307 TP308 TP402 TP618-TP620 TP1702 TP1705 TP1706 TP1708 TP1807 TP1808 TP1901 TP2101-TP2103 TP2201 TP2202 TP4411 TP4601 TP6001 TP6201 TP7201 TP7701 TP7901-TP7903 TP7905 TP9101-TP9104 TP9106 TP9107 = TPAD14-OP: tolerance: ZZ.PAD14.001
BATT1 = 88231-1001-LP: tolerance: 20.F1240.010
BIOS1 = SOIC8-1H86: tolerance: 072.25128.0D61
BIOS2 = DFN8A5060-G4135H32: tolerance: 072.25647.0D03
C501 C805 C1139-C1142 C1229 C1301 C1711 C2201 C2206 C2207 C2221 C2406-C2408 C2410-C2414 C2416 C2420-C2423 C2428 C2429 C2432 C2502 C2610 C2614 C2735 C3103 C3108 C3112 C3115 C3117-C3121 C3123 C3516 C3524 C3602 C4007 C4010 C5529 C5530 C5538 C5736 C5811-C5813 C6007 C6019 C6104 C6107 C6108 C6307 C6401 C6502 C7003 C7103-C7106 C7115-C7118 C7120 C7203-C7205 C7210 C7211 C7213 C7216 C9104 C9108 C9112 C9113 C9203 EC1707 EC1712 EC8940-EC8946 PC4438 PC4449 PC4602 = C402H22: tolerance: 78.10421.2FLDL
C801-C804 C806 C1102-C1111 C1114 C1116 C1117 C1119 C1121 C1207 C1214-C1221 C1225 C1226 C1313 C1315-C1322 C1326 C1327 C1805 C1806 C2202-C2205 C2209-C2217 C2219 C2222-C2230 C2418 C2525 C3122 C3126 C4043 C5536 C5541 C7202 C7612 C7614 C7622 C7630 C7631 C7633 C7807 C8011-C8014 C8018 C8028 C8036 C8050 C8101-C8110 C8115-C8122 C8131 C8132 C8601 C8627 C9201 C9202 EC8950-EC8953 EC8959 EC8960 EC8975 EC8977-EC8980 EC8991-EC8999 EC9001 FC8904-FC8906 FC9005 FC9006 PC5114 PC5307 PC8618 PC8629 PC8633 PC8634 = C0201H14: tolerance: 78.10510.5SL
C807 C1112 C1113 C1115 C1118 C1122 C1128-C1135 C2220 C3518 C3519 C3526 C3527 C4035 C4036 C7403 C7404 C8143-C8146 PC1001-PC1032 PC1034 PC1036-PC1084 PC4509-PC4512 PC4514-PC4517 PC4525 PC4527 PC4529 PC5201 PC5203 PC5205 PC5206 PC5217 PC8611 PC8613 PC8620 PC8621 = C603H40: tolerance: 78.22610.5BLDL
C1120 C1123 C1136-C1138 C2501 C2707 C4005 C4006 C4008 C4009 C4012 C4013 C4015 C6105 C6317 C6318 C7119 C7744-C7746 C7817 C8038-C8043 C9106 PC5112 PC5113 PC5124 = C603H36: tolerance: 78.10610.5BLDL
C1202-C1206 C1208-C1210 C1303 C1305 C1306 C1308 C1310 C2720 C2722 C2736 C2902 C7004 C7623 C7625 C7627 C7629 C7819 C7823 C7824 C7829 C8111-C8114 C8123-C8130 C8625 C8626 PC8627 PC8630 = C603H38: tolerance: 78.10610.5BL
C1222 C1323 C8803 = C402H22: tolerance: 78.22321.2FL
C1223 C1227 C7611 C7613 C7620 C7621 C7813 C7814 C7934 C8001-C8004 C8008 C8009 C8015 C8016 C8019-C8026 C8030-C8032 C8048 PC4507 = C603H36: tolerance: 78.47520.5BL
C1228 C1328 C8802 C8805-C8809 = C402H22: tolerance: 78.10421.L0L
C1231 C1304 C1307 C1309 C1311 C1324 C1325 C2702 C2703 C2710 C2711 C2715 C5505 C5517 C7206 = C402-TO0D2H28: tolerance: 078.10610.05FD
C1329 C6405 C7165 C7217 EC1202 EC1303 FC1102 FC1103 R1216 = C402H22: tolerance: 78.22510.5FLDL
C1603 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1603
C1604 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1604
C1605 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1605
C1606 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1606
C1607 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1607
C1608 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1608
C1611 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1611
C1612 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1612
C1701 PC5212 = C402H22: tolerance: 78.22124.2FLDL
C1702 C1703 C7215 = C402H22: tolerance: 78.22423.5FL
C1803 C1804 = C402H22: tolerance: 78.12034.1FLDL
C1807 C1808 C3116 C3125 = C402H22: tolerance: 78.15034.1FLDL
C1809 = C402H22: tolerance: 78.2R274.1FLDL
C2208 C2231 = C603H40: tolerance: 078.47610.05BD
C2218 C2604 C2907 C2908 C3110 C3124 C7615 C7624 C7634 C9109 PC4421 PC4422 PC4520 = C603H36: tolerance: 78.47520.5BLDL
C2405 = C402H22: tolerance: 78.10134.1FL
C2409 C5810 PC4431 PC4613 PC4622 PC4635 PC4637 PC5213 PC8609 = C402H22: tolerance: 78.10322.2FLDL
C2424 C2425 = C402H22: tolerance: 78.18034.1FLDL
C2426 C2705 C2708 C2709 PC5001 = C603H36: tolerance: 78.22523.5BLDL
C2431 C2435 PC4443 = C402H22: tolerance: 78.22224.2FL
C2503 = C603H36: tolerance: 78.47422.5BL
C2517 PC4420 PC4608 PC4625 PC4626 PC4628 PC4652 PC4654 = C402H22: tolerance: 78.22321.2FLDL
C2601 = C402-TO0D2H28: tolerance: 78.10610.5FL
C2602 C2612 C2704 C2706 C2714 C2718 C2721 C2723 C2741 C6501 C6505 C7632 C7801 C7802 C7805 C7808 C7809 C7902 C7905 C7906 C8029 C8034 C8035 C8049 C8051 EC6401 EC8936 FC8918 FC8919 PC4518 PC8614 = C402H22: tolerance: 78.10421.2FL
C2603 C2607 C5531 C5535 PC4441 PC4601 PC4611 PC4612 PC4623 PC4632 PC4640 = C402H22: tolerance: 78.22224.2FLDL
C2605 C4033 C4034 C6106 C7166 C7201 C7302-C7304 C7307 C8603 EC2201 EC6402 EC6404 EC6405 PC4406 PC4513 PC4603 PC4631 PC4633 PC5004 PC5102 PC5122 PC5123 PC5127 PC5204 PC5208 PC5214 PC8503 PC8506 PC8551 PC8553 PC8556 PC8572 PC8575 = C402H22: tolerance: 78.10422.5FLDL
C2606 = C603H36: tolerance: 78.47134.1BL
C2613 = C402H22: tolerance: 78.10134.1FLDL
C2713 C2717 = C603H38: tolerance: 78.10613.5BL
C2740 = C603H36: tolerance: 78.22523.L1L
C3102 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C3102
C3104 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C3104
C3107 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C3107
C3109 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C3109
C3202 = C1808H56: tolerance: 78.1013N.1AL
C3203 C4303-C4305 C8141 C8142 PC4615 PC4620 PC4644 PC8554 = C402H22: tolerance: 78.10324.2FLDL
C3507 C3517 C3525 C4031 C4032 C4041 C7207 C7212 PC4607 PC4708 PC4766 PC4809 PC4812 PC4866 PC4877 PC5120 PC8550 = C402H22: tolerance: 78.10523.5FLDL
C3520 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C3520
C3521 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C3521
C3522 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C3522
C3523 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C3523
C4001 C4002 C4011 C4017 C5539 C5540 = C402H22: tolerance: 78.47124.2FL
C4004 C4014 C4306 C5514 C7305 EC4301 PC4402-PC4405 PC4413 PC4418 PC4427 PC4434 PC4437 PC4446-PC4448 PC4502-PC4504 PC5002 PC5003 PC5209-PC5211 PC5216 = C805H58: tolerance: 78.10622.51LDL
C4301 C4302 C7306 = C603H36: tolerance: 078.10524.05BD
C4344 C5513 EC2002 EC2901-EC2904 EC4302 EC4307 EC4308 EC4312 EC4313 EC6403 EC8969 PC4432 PC4435 PC4442 PC4445 PC4616 PC4617 PC4619 PC4642 PC4643 PC4651 PC4706 PC4810 PC4813 PC5215 PC8552 = C402H22: tolerance: 78.10224.2FLDL
C4444 C7401 FC8963 FC8964 = C402H22: tolerance: 78.15224.2FLDL
C5503 C5504 C5520 C5599 C7610 PC5121 = C402H22: tolerance: 078.47510.05FD
C5512 C5516 C5528 C5809 C7616 EC1203 EC4311 EC4534 EC8911-EC8915 EC8927 EC8930 EC8932 EC8957 EC8963 EC8964 EC8974 EC8976 FC8901 FC8902 FC8907-FC8911 FC8917 FC8922 FC8931-FC8942 FC8944-FC8948 FC8951-FC8960 FC8962 FC8965-FC8967 FC8970 FC8981 FC8983-FC8988 FC8990-FC8999 FC9001 PC4501 PC4506 PC4508 PC4521 PC4522 PC4530-PC4532 PC8619 = C402H22: tolerance: 78.10422.5FL
C5521 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5521
C5522 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5522
C5523 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5523
C5524 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5524
C5525 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5525
C5526 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5526
C5724 = C402H22: tolerance: 78.10324.2FL
C5777 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5777
C5778 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5778
C5779 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5779
C5780 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5780
C5781 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5781
C5782 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5782
C5783 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5783
C5784 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5784
C5801 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C5801
C5802 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C5802
C5803 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C5803
C5804 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C5804
C5805 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C5805
C5806 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C5806
C5807 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C5807
C5808 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C5808
C5854 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C5854
C5862 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C5862
C5863 = C402H22: tolerance: 78.22523.5FL
C6008 C6018 = C402-TO0D2H28: tolerance: 78.10613.5FLDL
C6010 = C402H22: tolerance: 78.10322.2FLDL; signal model: Graser_C6010
C6011 = C402H22: tolerance: 78.10322.2FLDL; signal model: Graser_C6011
C6013 = C402H22: tolerance: 78.10322.2FLDL; signal model: Graser_C6013
C6014 = C402H22: tolerance: 78.10322.2FLDL; signal model: Graser_C6014
C6028 = C402H22: tolerance: 78.10322.2FLDL; signal model: Graser_C6028
C6029 = C402H22: tolerance: 78.10322.2FLDL; signal model: Graser_C6029
C6030 = C402H22: tolerance: 78.10322.2FLDL; signal model: Graser_C6030
C6031 = C402H22: tolerance: 78.10322.2FLDL; signal model: Graser_C6031
C6102 = C603H36: tolerance: 78.47520.L0L
C6201 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C6201
C6202 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C6202
C6302 = C402H22: tolerance: 078.22423.05FD; signal model: Graser_C6302
C6303 = C402H22: tolerance: 078.22423.05FD; signal model: Graser_C6303
C6304 C6305 EC1903 EC5503 EC5504 PC4610 PC4624 PC4639 PC8573 = C402H22: tolerance: 78.33034.1FLDL
C6306 C6308 PC4605 PC4630 PC4634 PC4653 = C402H22: tolerance: 078.47322.02FD
C6311 = C402H22: tolerance: 078.22423.05FD; signal model: Graser_C6311
C6312 = C402H22: tolerance: 078.22423.05FD; signal model: Graser_C6312
C6313 = C402H22: tolerance: 078.22423.05FD; signal model: Graser_C6313
C6314 = C402H22: tolerance: 078.22423.05FD; signal model: Graser_C6314
C6315 = C402H22: tolerance: 078.22423.05FD; signal model: Graser_C6315
C6316 = C402H22: tolerance: 078.22423.05FD; signal model: Graser_C6316
C6506 C6510 C6511 EC1801 EC1901 EC2503 EC2504 EC2601 EC2602 PC4430 = C402H22: tolerance: 78.10034.1FLDL
C7107 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C7107
C7108 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C7108
C7109 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C7109
C7110 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C7110
C7111 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C7111
C7112 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C7112
C7113 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C7113
C7114 = C402H22: tolerance: 78.10421.2FLDL; signal model: Graser_C7114
C7161 = C402H22: tolerance: 78.10422.5FLDL; signal model: Graser_C7161
C7162 = C402H22: tolerance: 78.10422.5FLDL; signal model: Graser_C7162
C7163 = C402H22: tolerance: 78.10422.5FLDL; signal model: Graser_C7163
C7164 = C402H22: tolerance: 78.10422.5FLDL; signal model: Graser_C7164
C7167 = C0201H13: tolerance: 078.33410.05S1; signal model: Graser_C7167
C7168 = C0201H13: tolerance: 078.33410.05S1; signal model: Graser_C7168
C7169 = C0201H13: tolerance: 078.33410.05S1; signal model: Graser_C7169
C7170 = C0201H13: tolerance: 078.33410.05S1; signal model: Graser_C7170
C7208 C7209 = C402H24: tolerance: 78.39124.2FL
C7214 C7810-C7812 C7825-C7828 = C603H32: tolerance: 78.10524.5BL
C7405 EC8923-EC8925 EC8929 EC8955 EC8962 PC4526 PC4533 = C402H22: tolerance: 78.10224.2FL
C7601 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7601
C7602 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7602
C7603 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7603
C7604 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7604
C7605 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7605
C7606 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7606
C7607 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7607
C7608 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7608
C7626 C7628 C7818 C7820-C7822 C7935 C8010 C8017 C8047 PC8628 PC8631 = C603H40: tolerance: 78.22610.5BL
C7907 C7908 = C402H22: tolerance: 78.18034.1FL
C8136 C8140 = C402H22: tolerance: 78.82124.2FLDL
C8501 = CT7343H83: tolerance: 79.33612.20L
C8502 = CT3528H79: tolerance: 080.22612.0001
