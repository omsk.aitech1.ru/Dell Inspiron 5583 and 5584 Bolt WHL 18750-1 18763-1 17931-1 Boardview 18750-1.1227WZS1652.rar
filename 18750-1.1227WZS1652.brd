# Allegro board 18750-1.1227WZS1652.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V0.85A_VID0: length 4.2
  BOTTOM w0.089: TP2201.1 106.78,80.87 106.61,81.05 106.61,81.94 106.3,82.25 106.3,84.14 CPU1.CB36
V0.85A_VID1: length 3.8
  BOTTOM w0.089: TP2202.1 106,81.55 106,84.36 106.34,84.7 CPU1.CB35
V3D3_STB: length 4.1
  TOP w0.127: R2708.2 21.35,14.81 v2(22.43,13.74) 22.43,13.74 22.44,13.74 22.61,13.74 22.78,13.57 HDA27.16
VBUS_P_CTRL: length 32.7
  TOP w0.089: v1(41.41,120.55) 40.98,120.55 R7405.2 40.94,120.98 41.28,120.98 41.94,121.64 41.94,121.67 42.3,122.02 42.46,122.02 42.65,122.22 U7403.B4 ; U7201.14 v1(37.85,111.16)
  L5 w0.089: v1(37.85,111.16) 38.3,111.61 38.3,113.32 36.71,114.9 36.71,119.15 36.97,119.41 37.37,119.41 39.4,121.44 40.51,121.44 v1(41.41,120.55)
  BOTTOM w0.089: Q7404.2 26.27,109.58 26.74,110.05 27.17,110.05 27.27,110.15 27.27,110.3 27.51,110.54 27.82,110.54 v2(27.92,110.64) 27.92,110.64 28.12,110.64 28.6,110.16 29.11,110.16 29.47,110.52 32.13,110.52 33,111.39 35.05,111.39 35.38,111.06 37.74,111.06 v1(37.85,111.16)
VBUS_P_CTRL_R: length 7.1
  BOTTOM w0.089: 26.58,111.51 26.58,111.79 27.3,112.51 v2(27.9,112.51) 27.9,113.27 R7430.1 27.03,114.14 27.03,114.89 27.38,115.24 R7423.2 ; 26.58,111.51 26.92,111.17 Q7404.6 ; 26.58,111.51 26.27,111.2 Q7404.5
VCC3PD:
  vias: v2(53.22,125.66)
VCCCORE_SENSE: length 115
  TOP w0.127: v1(91.11,149.89) v2(91.32,149.28) ; R707.2 88.4,104.02 88.4,103.86 88.9,103.36 v1(88.93,103.36)
  L3 w0.127: v1(64.14,106.17) 63.94,106.37 63.59,106.37 63.1,106.86 63.1,107.73 57.1,113.72 57.1,116.61 54.81,118.9 53.26,118.9 51.2,120.96 51.2,123.66 52.48,124.95 52.48,131.07 54.44,133.02 55.45,133.02 56.34,133.91 56.34,138.52 56.76,138.94 59.53,138.94 62.48,141.89 65.1,141.89 68.78,145.57 70.77,145.57 71.46,144.87 75.05,144.87 75.57,144.35 80.78,144.35 82.68,146.25 82.68,147.27 83.09,147.68 84.63,147.68 85.52,148.57 90.6,148.57 91.24,149.2 91.24,149.76 v1(91.11,149.89)
  L5 w0.127: v1(64.14,106.17) 64.34,106.38 67.24,106.38 68.81,107.95 77.69,107.95 78.12,108.38 85.34,108.38 87.46,106.27 87.46,104.85 88.51,103.8 88.51,103.78 v1(88.93,103.36)
  BOTTOM w0.127: v1(88.93,103.36) CPU1.AN6 ; v1(91.11,149.89) PR4665.1
VCCDSW_ON: length 284.2
  TOP w0.089: v1(32.77,68.4) 32.77,68.52 34.56,70.31 34.7,70.46 37.07,70.46 38.24,69.29 U2401.88 ; v1(172.04,62.68) 172.34,62.97 172.34,68.66 172.92,69.25 172.92,70.64 v2(172.84,70.73) 172.52,71.05 172.52,73.27 171.6,74.19 171,74.79 v1(170.06,74.79)
  L5 w0.089: v1(32.77,68.4) 32.77,67.92 30.81,65.96 30.81,61.05 26.69,56.93 26.69,54.65 25,52.96 25,51.49 23.35,49.84 23.35,48.38 22.71,47.74 22.71,47.12 21.85,46.25 21.85,33.41 22.26,33 24.78,33 27.26,35.48 31.01,35.48 31.87,36.34 34.21,36.34 35.59,37.72 35.59,39.74 38.28,42.44 52.89,42.44 55.06,40.27 59.51,40.27 60.84,38.93 62.92,38.93 64.35,37.5 76.14,37.5 77.96,39.31 93.02,39.31 93.47,39.76 96.82,39.76 97.43,39.15 99.55,39.15 100.43,40.03 103.23,40.03 104.47,41.27 v1(106.75,41.27)
  L6 w0.089: v1(106.75,41.27) 107.05,40.96 108.06,40.96 108.59,41.49 108.59,41.5 109.17,42.09 110.11,42.09 112.2,44.17 125,44.17 127.35,41.82 128.01,41.82 128.26,41.57 128.26,40.91 128.87,40.3 129.87,40.3 130.5,39.68 144.08,39.68 148.95,34.81 149.15,34.81 149.15,34.8 156.59,34.8 158.51,36.71 159.72,36.71 160.57,35.87 165.28,35.87 165.97,36.55 169.31,36.55 172.92,40.16 174.07,40.16 174.67,40.77 174.67,41.12 174.64,41.16 174.64,45.75 175.21,46.32 175.21,47.66 174.01,48.85 174.01,53.8 173.34,54.47 173.34,59.99 171.74,61.59 171.74,62.38 v1(172.04,62.68) ; v1(170.06,74.79) 168.97,74.79 164.26,79.5 164.26,82.04 162.74,83.57 162.74,86.51 v1(161.22,88.04)
  BOTTOM w0.089: v1(161.22,88.04) 161.22,88.93 159.85,90.3 157.63,90.3 D2503.2 156.29,90.25 155.51,90.25 155.37,90.38 C2525.1 155.37,91.95 155.07,92.25 R2520.2
VCCGT_SENSE: length 69.3
  L3 w0.127: v1(64.44,109.32) 64.06,109.18 63.95,109.16 63.93,109.17 62.9,109.17 61.12,110.95 61.12,112.93 61.98,113.79 61.98,115.93 61.17,116.74 58.37,116.74 55.39,119.72 53.74,119.72 52.66,120.8 52.66,121.13 52.89,121.36 52.89,122.07 53.29,122.48 53.29,130.78 54.59,132.08 55.59,132.08 57.18,133.67 57.18,137.36 57.93,138.11 59.78,138.11 62.79,141.12 65.42,141.12 67.8,143.51 69.7,143.51 70.11,143.91 70.11,144.11 70.31,144.31 v1(70.31,144.34)
  BOTTOM w0.127: 69.15,110.49 v2(69.28,110.61) ; 69.15,110.49 69.45,110.19 69.45,109.91 R807.2 69.47,109.47 69.47,108.71 70.96,107.22 70.96,106.74 70.84,106.61 70.84,106.36 70.85,106.35 70.85,106.17 71.15,105.87 CPU1.E3 ; 69.15,110.49 69.05,110.59 66.95,110.59 65.1,108.74 64.72,108.74 64.44,109.02 v1(64.44,109.32) ; v1(70.31,144.34) 70.12,144.53 70.12,144.53 70.03,144.62 70.03,144.78 PR4667.1
VCCPD_VBUS_ACK: length 37.9
  TOP w0.089: v1(14.74,130.05) 14.61,130.18 PR4430.2 ; v1(37.7,120.7) 37.97,120.98 R7424.2 38.79,121.38 39.19,121.38 39.78,121.97 U7419.A2
  BOTTOM w0.089: v1(14.74,130.05) 15.21,130.53 15.57,130.53 16.15,129.95 16.5,129.95 16.79,129.65 16.79,124.82 16.53,124.56 16.53,121.08 16.79,120.82 26.17,120.82 26.9,120.09 v2(27.18,120.09) 28.27,120.09 30.1,121.91 32.8,121.91 33.56,121.16 37.24,121.16 v1(37.7,120.7)
VCCRTCEXT: length 3
  TOP w0.254: v2(99.75,93.22) 100.53,92.45 C2201.1 100.64,92.15 v1(101.35,91.45)
  BOTTOM w0.254: CPU1.BP24 v1(101.35,91.45)
VCCSA_SENSE: length 115.8
  TOP w0.127: v2(68.02,150.29) 67.92,150.39 ; 67.92,150.39 67.52,149.99 67.16,149.99 66.98,149.81 v1(66.98,149.79) ; 67.92,150.39 68.5,150.97 72.72,150.97 73,150.68 73,150.43 PR4601.2 ; v1(96.31,102.76) 96.24,102.76 R810.2
  L3 w0.127: v1(66.98,149.79) 66.96,149.79 66.76,149.99 66.48,149.99 66.25,149.76 66.25,148.39 67.01,147.62 67.01,144.18 64.98,142.14 62.37,142.14 59.42,139.19 56.54,139.19 56.09,138.74 56.09,134.21 55.24,133.37 53.21,133.37 51.08,131.24 51.08,126.67 51.97,125.79 51.97,124.89 50.94,123.86 50.94,120.69 52.91,118.72 52.91,118.17 53.66,117.43 55.68,117.43 56.54,116.56 56.54,107.35 59.34,104.55 62.88,104.55 63.26,104.93 63.26,105.38 v1(63.01,105.64)
  L5 w0.127: v1(96.31,102.76) 96.13,102.76 94.64,104.25 93.57,104.25 92.11,105.7 90.91,105.7 88.61,108 87.46,108 85.3,110.16 70.84,110.16 69.62,108.94 68.4,108.94 67.09,107.63 63.99,107.63 63.2,106.84 63.2,105.83 v1(63.01,105.64)
  BOTTOM w0.127: CPU1.BG7 96.51,102.76 v1(96.31,102.76)
VCCST_PWRGD_R: length 13.3
  BOTTOM w0.089: ED1707.2 95.29,116.37 94.58,115.66 R1716.2 95.3,115.36 R1719.1 95.35,114.91 95.27,114.83 C1711.1 95.27,113.8 95.01,113.54 95.01,111.8 v2(95.14,111.67) 95.63,111.18 95.63,108.58 97.23,106.98 97.23,106.55 97.91,105.88 CPU1.BJ2
VCCSTG_EN_R1: length 159.8
  TOP w0.089: v1(89.36,41.61) 89.33,41.63 89.33,42.17 89.21,42.29 v2(88.7,42.29) 88.4,42.29 88.27,42.17 88.27,40.74 R4017.2 ; v1(127.51,75.16) 127.51,74.02 128.17,73.36 128.17,70.11 124.13,66.07 v1(124.13,65.71) ; U4002.4 108.89,121.28 109.58,121.96 109.58,122.45 C4033.1 110.9,122.94 111.03,122.81 111.84,122.81 113.24,124.21 114.05,124.21 115.83,122.43 117.55,122.43 119.71,120.27 119.71,118.9 120.3,118.31 120.3,117.71 121.67,116.34 121.67,115.5 121.49,115.32 121.49,113.74 122.23,113 123.78,113 124.56,112.22 124.56,111.81 v1(124.82,111.56) ; U4003.4 96.49,72.51 95.9,71.92 v1(94.75,71.92)
  L6 w0.089: v1(127.51,75.16) 128.12,75.77 128.12,84.66 127.59,85.19 127.59,94.64 127.87,94.92 127.87,100.02 127.08,100.81 127.08,104.55 126.52,105.11 126.52,109.41 124.82,111.11 v1(124.82,111.56) ; v1(89.36,41.61) 90.73,42.98 96.8,42.98 98.99,45.17 98.99,46.62 99.01,46.63 99.01,48.42 90.81,56.62 90.81,64.06 94.75,68 v1(94.75,71.92)
  BOTTOM w0.089: U4007.4 90.06,40.85 89.36,41.55 v1(89.36,41.61) ; v1(124.13,65.71) 123.83,65.41 112.4,65.41 104.76,73.05 95.87,73.05 v1(94.75,71.92)
VCCSTU_EN_R: length 6.3
  TOP w0.089: v1(113.77,113.74) 113.65,113.74 111.83,115.56 U4006.4
  BOTTOM w0.089: v2(114.18,116.84) 114.05,116.71 R4024.2 C4034.1 113.77,114.91 v1(113.77,113.74)
VDD: length 43.9
  TOP w0.254: PR4448.1 v1(195.08,40.97) ; v1(205.9,50.52) 206.83,50.52 PR4449.1 ; PR4429.1 PR4427.1 207.72,42.19 v2(207.72,43.16) 207.53,43.16 206.96,43.73 v1(206.96,43.84)
  L3 w0.254: v1(196.27,55.47) 196.27,55.21 196.82,54.66 197.2,54.66 197.24,54.62 203.15,54.62 205.9,51.88 v1(205.9,50.52)
  L6 w0.254: v1(195.08,40.97) 197.34,40.97 198.29,41.92 201.1,41.92 201.41,42.23 204.4,42.23 205.56,43.39 ; v1(206.96,43.84) 206.01,43.84 205.56,43.39 ; v1(205.9,50.52) 204.85,49.47 204.85,47.06 204.42,46.64 204.42,44.52 205.56,43.39
  BOTTOM w0.203: v1(205.9,50.52) 205.9,50.37 205.56,50.04 PU4401.18
  BOTTOM w0.254: PR4405.2 197.98,53.35 197.47,53.86 197.43,53.9 197.43,54.31 v1(196.27,55.47) ; v1(205.9,50.52) 205.92,50.5 206.42,50.5 PC4422.1
VDD10: length 29.4
  TOP w0.203: U3101.22 48.74,84.14 48.78,84.18 49.41,84.18 v1(49.59,84.35) ; v1(43.43,83.96) 43.44,83.97 43.44,84.01 43.57,84.14 U3101.3 ; U3101.30 45.49,86.06 45.7,86.27 v1(45.7,86.31) ; v1(42.84,81.74) 42.87,81.71 43.56,81.71 43.99,82.14 U3101.8
  BOTTOM w0.203: v1(49.59,84.35) 49.02,84.35 C3112.1
  BOTTOM w0.305: v1(49.59,84.35) 50.31,85.07 50.31,85.97 C3123.1 50.63,86.39 49.38,86.39 49.05,86.72 49.05,87.02 48.9,87.17 R3101.2 47.78,87.17 C3122.1 46.94,87 46.69,87.25 45.57,87.25 ; C3120.1 43.13,81.45 v1(42.84,81.74) 43.13,82.02 43.46,82.02 43.79,81.69 C3108.1 44.17,81.87 C3126.1 44.17,83.09 C3115.1 43.99,83.42 43.47,83.94 43.44,83.94 v1(43.43,83.96) 43.43,85.3 43.08,85.65 42.27,85.65 41.76,86.16 41.76,86.82 42.34,87.4 v2(43.46,87.4) 45.42,87.4 45.57,87.25 ; C3119.1 46.15,85.99 45.83,86.31 v1(45.7,86.31) 45.7,86.71 45.57,86.84 45.57,87.25
VDDD: length 52.7
  TOP w0.152: R7212.1 44.08,106.23 v1(44.53,106.23)
  TOP w0.254: RN7202.1 35.36,109.94 35.18,109.76 35.18,108.73 v1(35.22,108.69)
  TOP w0.305: R7211.2 42.7,115.23 v1(42.83,115.36) ; RN7202.2 35.76,108.96 35.49,108.69 v1(35.22,108.69)
  TOP w0.508: v1(52.02,127.33) 52.4,126.95 R7204.2
  L5 w0.508: v1(39.3,116.31) 39.2,116.21 39.2,107.81 v1(39.5,107.5)
  L6 w0.152: v1(39.5,107.5) 42.14,107.5 42.16,107.49 43.78,107.49 44.05,107.75 44.62,107.75 44.99,107.37 44.99,106.69 v1(44.53,106.23)
  L6 w0.508: v1(39.5,107.5) v1(39.5,106.87) 38.96,106.33 36.15,106.33 35.22,107.25 v1(35.22,108.69) ; v1(42.37,121.49) 43.81,121.49 46.15,123.83 46.15,124.62 49.32,127.79 51.57,127.79 v1(52.02,127.33)
  BOTTOM w0.356: v1(52.02,127.33) v2(52.48,127.92)
  BOTTOM w0.508: v1(42.37,121.49) 42.37,119.99 41.76,119.38 41.76,116.99 41.08,116.31 ; v1(42.83,115.36) 42.18,114.71 41.51,114.71 41.08,115.14 41.08,116.31 ; 41.08,116.31 v1(39.3,116.31)
VDDIO: length 38.5
  TOP w0.305: R7414.1 41.99,119.13 40.69,119.13 v1(40.64,119.18) 40.34,119.18 R7402.2
  TOP w0.508: R7210.2 53.77,125.02 52.76,125.02 52.28,125.5 52.02,125.5 v2(51.72,125.8) v1(51.72,126.67)
  L5 w0.508: v1(40.46,106.83) 40.46,108.84 39.94,109.36 39.94,114.9 41.79,116.74 41.79,118.04 v1(40.64,119.18)
  L6 w0.508: v1(51.72,126.67) 51.44,126.95 49.82,126.95 48.82,125.95 48.82,120.02 47.9,119.1 46.29,119.1 45.25,120.13 42.54,120.13 41.58,119.18 v1(40.64,119.18)
VDDQ_PWRGD: length 2.1
  TOP w0.089: v2(81.24,36.35) 81.71,36.82 PG5114.1 82.26,37.71 R4011.1
VSSCORE_SENSE: length 115.7
  TOP w0.127: v1(88.93,104) 88.93,104.31 R708.1 ; v1(91.16,150.55) v2(91.7,151.05)
  L3 w0.127: v1(91.16,150.55) 91.16,150.46 91.56,150.07 91.56,149.7 91.49,149.64 91.49,149.1 90.71,148.31 85.62,148.31 84.73,147.42 83.19,147.42 82.93,147.17 82.93,146.15 80.88,144.1 75.46,144.1 74.94,144.62 71.36,144.62 70.66,145.31 68.89,145.31 65.2,141.63 62.58,141.63 59.63,138.69 56.87,138.69 56.59,138.41 56.59,133.81 55.55,132.77 54.54,132.77 52.73,130.96 52.73,124.84 51.45,123.56 51.45,121.07 53.37,119.15 54.92,119.15 57.36,116.71 57.36,113.83 63.35,107.83 63.35,106.96 63.69,106.62 63.97,106.62 v1(64.18,106.83)
  L5 w0.127: v1(64.18,106.83) 64.37,106.63 67.13,106.63 68.7,108.2 77.58,108.2 78.02,108.64 85.45,108.64 87.71,106.38 87.71,104.95 88.66,104 v1(88.93,104)
  BOTTOM w0.127: 90.43,150.69 90.59,150.52 91.11,150.52 91.14,150.55 v1(91.16,150.55) ; v1(88.93,104) CPU1.AN5
VSSGT_SENSE: length 68.7
  TOP w0.127: v1(69.68,144.35) v2(69.68,144.91)
  L3 w0.127: v1(69.68,144.35) 69.68,144.32 69.85,144.15 69.85,144.02 69.6,143.77 67.7,143.77 65.31,141.38 62.69,141.38 59.68,138.37 57.82,138.37 56.92,137.47 56.92,133.78 55.48,132.34 54.49,132.34 53.04,130.89 53.04,122.58 52.63,122.18 52.63,121.47 52.4,121.24 52.4,120.7 53.63,119.47 55.28,119.47 58.27,116.49 61.06,116.49 61.73,115.82 61.73,113.9 60.86,113.04 60.86,110.85 60.94,110.77 62.79,108.92 63.85,108.92 64,108.81 v1(64.09,108.57)
  BOTTOM w0.127: CPU1.D2 70.17,106.3 70.17,106.62 69.98,106.82 69.97,106.82 69.95,106.83 69.95,107.87 69.21,108.61 69.21,109.42 R808.1 69.19,109.93 69.19,110.09 68.97,110.31 68.95,110.34 67.06,110.34 65.2,108.48 64.62,108.48 64.4,108.7 64.22,108.7 v1(64.09,108.57) ; v1(69.68,144.35) 69.7,144.35 69.71,144.36 69.71,144.75 PR4668.1
VSSSA_SENSE: length 116.3
  TOP w0.127: PR4602.2 73.26,150.52 73.26,150.79 72.82,151.22 69.73,151.22 ; v2(69.73,151.36) 69.73,151.22 ; 69.73,151.22 68.39,151.22 67.41,150.24 67.23,150.24 v1(66.99,150.48) ; v1(95.38,102.8) 95.03,103.15 R809.1
  L3 w0.127: v1(63.74,105.61) 63.52,105.38 63.52,104.83 62.99,104.29 59.24,104.29 56.29,107.24 56.29,116.46 55.57,117.17 53.55,117.17 52.66,118.07 52.66,118.62 50.69,120.59 50.69,123.97 51.72,125 51.72,125.68 50.83,126.57 50.83,131.34 53.1,133.62 55.13,133.62 55.83,134.32 55.83,138.84 56.44,139.45 59.32,139.45 62.26,142.39 64.87,142.39 66.76,144.28 66.76,147.52 65.99,148.29 65.99,149.86 66.37,150.24 66.75,150.24 v1(66.99,150.48)
  L5 w0.127: v1(95.38,102.8) 95.38,103.15 94.54,103.99 93.47,103.99 92.01,105.45 90.8,105.45 88.5,107.75 87.35,107.75 85.19,109.91 70.95,109.91 69.73,108.69 68.5,108.69 67.2,107.38 64.09,107.38 63.45,106.73 63.45,105.91 v1(63.74,105.61)
  BOTTOM w0.127: CPU1.BE7 95.55,102.8 v1(95.38,102.8)
0D6V_PWR: length 43
  TOP w0.508: v1(92.5,28.6) 92.5,38.03 v2(93.05,38.58) 93.5,39.03 93.5,40.31
  L6 w0.508: v1(92.5,28.6) 93.39,27.71 106.89,27.71 108.29,29.11 109.3,29.11 109.76,28.65 113.29,28.65 113.36,28.58 113.37,28.58 113.74,28.2 113.74,28.2 113.97,27.97 116.28,27.97 117.81,29.49 120.92,29.49 v1(121.18,29.23)
0D6V_S0: length 45.4
  TOP w0.305: C1324.1 174.5,43.4 C1325.1 ; C1324.1 174.05,44.76 v1(173.82,44.76) ; C1324.1 174.5,45.01 C1327.1 174.67,45.64 C1326.1
  TOP w0.356: v2(142.73,41.99) v1(143.28,41.99)
  L6 w0.508: v1(143.28,41.99) 143.28,41.58 148.16,36.7 149.23,36.7 149.61,37.09 155.76,37.09 155.79,37.12 155.84,37.12 157.21,38.49 167.85,38.49 169.65,40.29 171.1,40.29 173.15,42.34 173.15,44.31 173.6,44.76 v1(173.82,44.76)
  BOTTOM w0.279: 96.58,41.76 DM1.258
  BOTTOM w0.305: DM2.258 172.78,44.22 173.31,44.76 v1(173.82,44.76)
  vias: v3(97.79,41.71)
1D0V_S5: length 106.1
  TOP w0.305: R2402.1 41.68,73.9 41.61,73.98 41.61,73.98 v1(41.38,74.21)
  L3 w0.305: v1(41.38,74.21) 42.48,75.3 42.48,75.31 42.88,75.71 42.88,76.23 42.47,76.64 42.47,80.27 42.01,80.72 42.01,92.6 v1(42.36,92.95)
  L5 w0.305: v1(42.36,92.95) 43.32,93.91 45.21,93.91 45.82,94.52 45.82,100.99 46.94,102.11 46.94,103.54 45.55,104.93 45.55,107.33 46.86,108.65 48.59,108.65 48.63,108.62 49.07,108.62 49.41,108.96 49.41,111.81 51.59,114 52.48,114 52.78,114.3 52.78,115.06 53.9,116.18 53.9,116.69 58.35,121.13 58.35,121.34 59.13,122.12 63.81,122.12 64.23,122.54 87.59,122.54 87.68,122.45 89.31,122.45 89.89,123.04 102.19,123.04 v4(103.42,124.27)
  vias: v1(100.64,93.91) v1(101.37,99.01) v1(101.35,94.8) v1(102.01,99.01) v1(102,98.16) v1(102.64,99.01) v1(102.64,94.79) v1(102.65,95.64) v1(103.29,98.16) v1(103.29,97.34) v1(103.94,97.31) v1(103.96,95.65) v1(103.95,94.8) v1(104.6,94.79) v1(105.24,99.01) v1(105.25,94.8) v2(101.48,123.5) v2(112.19,99.95) v4(103.84,125) v4(104.35,124.26) v4(104.8,125) v4(105.26,124.26)
1D0V_VCCA_XTAL: length 8.4
  TOP w0.254: v1(116.13,103.76) 116.13,103.16 115.64,102.67 C2219.1 115.17,102.26 115.29,102.13 v2(115.29,101.88) 114.4,101.88 C2231.1 113.67,102.62 R2202.2
  BOTTOM w0.254: CPU1.CP5 114.48,104.11 114.58,104.22 116,104.22 116.13,104.09 v1(116.13,103.76)
1D0V_VCCAMPHYPLL: length 12.1
  TOP w0.254: R2205.2 104.22,116.58 C2208.1 104.35,116.46 C2209.1 104.35,115.5 104.07,115.22 v2(104.07,114.95) 104.14,114.88 104.14,107.84 v1(103.43,107.14)
  BOTTOM w0.114: CPU1.BV2 v1(103.43,107.14)
1D0V_VCCDSW: length 1.2
  TOP w0.254: C2213.1 102.87,91.99 102.63,92.24 v1(102.63,92.29)
  BOTTOM w0.254: CPU1.BT24 102.63,92.17 v1(102.63,92.29)
1D0V_VCCPRIM_MPHY:
  vias: v1(103.31,99) v1(103.95,99) v1(104.6,99) v2(103.62,99.49)
1D2V_S3: length 162.3
  TOP w0.305: v1(43.46,44.34) 43.43,44.3 C1319.1 ; C1318.1 34.33,46.66 v1(34.01,46.66) ; v1(37.32,46.92) 37.36,46.87 C1316.1 ; v1(48.29,48.26) 48.52,48.26 C1317.1
  BOTTOM w0.09: v1(84.95,83.26) CPU1.AH36 ; CPU1.AD36 82.43,83.25 v1(82.42,83.23)
  BOTTOM w0.102: CPU1.AY36 92.5,83.1 92.49,83.09 v1(92.49,83.08) ; CPU1.AM36 87.46,83.25 v1(87.44,83.22) ; CPU1.Y36 79.91,84.05 79.91,84.05 v1(79.91,83.24)
  BOTTOM w0.127: v1(98.21,82.39) 97.8,82.8 97.8,84.01 CPU1.BH36
  BOTTOM w0.254: CPU1.AH32 85.26,87.25 v1(85.26,87.83) ; CPU1.AN32 88.61,86.85 v1(88.93,87.17) ; CPU1.R32 76.66,86.69 v1(76.96,86.39) ; DM1.178 76.58,44.12 76.58,44.12 76.58,45.19 77.14,45.75 v1(77.57,45.75) ; CPU1.AW32 v1(92.59,87.22)
  BOTTOM w0.279: v1(59.13,45.09) 59.6,44.63 59.6,44.22 59.58,44.2 DM1.118 ; DM2.220 163.28,44.57 162.84,45.01 v1(162.76,45.01) ; v1(140.31,44.35) 140.31,44.28 140.28,44.24 DM2.136 ; 72.08,41.64 DM1.160 v1(72.08,44.34) ; v1(48.29,48.26) 48.34,48.26 48.83,48.75 DM1.75 ; DM1.178 76.58,42.08 75.95,41.45 ; DM1.141 65.33,50.25 65.87,49.71 66.66,48.99 v1(67.03,48.99) ; v1(57.61,45.01) 57.65,45.01 58.1,44.56 58.1,44.13 58.08,44.11 DM1.112 ; v1(43.46,44.34) 43.46,44.3 43.55,44.21 43.55,42.92 DM1.54 ; DM2.33 114.53,48.98 115.34,48.17 v1(115.34,47.79) ; DM2.178 152.78,44.13 152.72,44.18 152.72,45.23 153.19,45.7 v1(153.29,45.7) ; v1(146.75,44.69) 146.78,44.66 DM2.154 ; DM2.163 149.03,49.03 148.21,48.22 148,48.22 v1(148,48.21) ; v1(54.59,45.16) 54.59,44.43 54.08,43.91 DM1.96 ; v1(138.53,49.63) DM2.129 ; DM1.123 60.83,47.49 60.13,46.8 v1(59.71,46.8) ; v1(69.08,44.4) 69.08,44.4 DM1.148 ; DM1.12 33.08,43.83 33.15,43.91 33.15,44.17 33.15,44.17 33.15,44.94 33.15,44.95 33.15,46.1 33.71,46.66 v1(34.01,46.66) ; DM2.147 145.03,49.07 146.33,47.76 v1(146.51,47.76) ; DM2.130 v1(138.78,44.37) ; v1(64.34,49.25) 64.34,49.3 63.83,49.82 DM1.135 ; v1(136.88,46.43) 136.88,47.7 137.03,47.84 DM2.123 ; DM2.124 137.28,44.15 137.3,44.17 137.3,44.6 136.88,45.02 v1(136.78,45.02) ; DM2.54 119.78,46.85 v1(119.95,47.02) ; DM2.111 134.03,49.24 133.27,48.49 v1(133.27,48.29) ; DM1.124 61.08,44.18 61.1,44.2 61.1,44.55 60.68,44.97 v1(60.58,44.97) ; v1(133.8,44.98) 133.88,44.98 134.3,44.56 134.3,44.13 134.28,44.11 DM2.112 ; DM1.117 59.33,49.37 59.45,49.25 59.45,49.24 59.76,48.93 59.76,48.93 v1(59.95,48.75) ; DM1.142 65.58,44.16 65.56,44.17 v1(65.56,44.34) ; DM1.159 71.83,52.13 71.95,52.25 72.69,52.25 72.81,52.13 72.81,51.11 DM1.163 72.83,50.17 73.26,49.73 v1(73.26,49.66) ; v1(135.59,49.67) 135.53,49.73 DM2.117 ; v1(148.03,49.58) DM2.159 148.03,52.03 147.69,52.36 146.72,52.36 146.53,52.16 DM2.153 ; v1(141.81,44.71) 141.78,44.67 DM2.142 ; v1(69.35,47.8) 69.1,47.8 68.83,48.08 DM1.147 ; DM1.129 62.33,49.39 v1(61.65,48.72) ; v1(70.54,44.41) 70.54,44.35 70.58,44.32 DM1.154 ; DM1.130 62.58,44.62 v1(62.57,44.62) ; DM1.136 64.08,44.5 v1(64.08,44.5) ; DM1.111 v1(57.83,49.64) ; v1(148.28,44.4) 148.28,44.4 DM2.160 ; v1(145.28,44.34) DM2.148 ; DM1.153 v1(70.33,49.67) ; DM2.118 v1(135.78,41.49)
  BOTTOM w0.305: DM2.75 125.03,50 124.72,49.69 v1(124.72,49.07) ; CPU1.BE32 96.09,87.15 v1(96.29,87.15) ; v1(83.01,46.76) 82.4,46.76 81.83,47.33 DM1.199 ; DM2.124 137.28,41.55 ; DM1.241 92.33,48.04 v1(93.13,47.23) ; v1(86.66,46.19) 86.74,46.19 87.16,45.77 87.16,45.31 87.08,45.23 DM1.220 ; DM2.135 v1(140.03,49.66) ; DM2.199 158.03,48.72 v1(157.64,48.34) ; DM2.12 109.28,44.45 108.44,45.29 108.44,45.61 108.67,45.84 v1(108.67,45.98) ; DM1.33 38.33,47.92 v1(37.32,46.92) ; v1(142.57,49.68) 141.79,49.68 141.53,49.94 DM2.141 ; v1(168.53,49.51) DM2.241 ; DM2.96 v1(130.28,44.59)
  vias: v2(115.98,51.46) v2(119.23,51.64) v2(122.76,50.98) v2(144.71,51.56) v2(147.81,51.26) v2(150.93,51.61) v4(59.85,78.59) v4(59.81,77.75) v4(59.85,76.7) v4(59.85,75.86)
1D2V_VCCSFR_OC: length 12.8
  L6 w0.508: v1(101.34,73.78) 101.61,74.04 101.61,80.09 101.3,80.4 101.3,80.48 99.9,81.87 99.9,85.75
  vias: v1(99.86,89.81) v2(101.98,73.71)
1D05V_PWR:
  vias: v2(99.93,124.39) v2(101.73,124.44) v4(98.05,128.45) v4(98.05,127.56) v4(98.07,126.72) v4(98.9,128.32) v4(98.9,127.38) v4(103.34,130.1) v4(103.36,129.21) v4(103.37,128.32) v4(103.37,127.43) v4(104.24,130.1) v4(104.24,129.21) v4(104.24,128.32) v4(104.24,127.43)
1D05V_S5_PWRGD: length 6.8
  TOP w0.089: R4029.1 96.6,139.98 v1(96.68,139.9) ; v2(100.59,139.6) v1(100.49,138.87)
  L5 w0.089: v1(96.68,139.9) 97.31,139.27 100.09,139.27 v1(100.49,138.87)
  BOTTOM w0.089: v1(100.49,138.87) 100.95,138.87 101.08,138.74 PU5201.1
1D8V_1V_VGA_S0: length 6.4
  TOP w0.508: C7629.1 129.63,135.28 v1(128.83,136.08) 128.3,135.54 v1(128.27,135.54) ; C7629.1 129.66,135.3 L7801.2 ; C7629.1 129.65,134.9 129.6,134.77 R8605.1 ; v1(134.21,127.61) 134.22,127.6 134.22,127.2 134.89,126.53 L7901.1
  vias: v1(130.58,147.63) v1(131.13,148.22) v2(130.18,148.71)
1D8V_AON_EN: length 96.1
  TOP w0.089: Q8701.2 103.43,144.96 103.06,144.59 101.86,144.59 v2(100.39,143.12) 100.05,143.12 99.08,142.15 99.08,141.62 v1(98.73,141.28) 99.41,140.6 U8802.4
  L5 w0.089: v1(117.78,128.98) 117.78,128.32 136.12,109.98 147.91,109.98 148.02,109.87 148.91,109.87 149,109.96 152.4,109.96 152.75,110.31 153.27,110.31 155.75,107.82 157.03,107.82 157.6,107.25 162.67,107.25 163,107.58 165.52,107.58 166.53,108.59 v1(166.53,108.74)
  L6 w0.089: v1(98.73,141.28) 99.01,141 99.32,141 99.46,141.13 103.4,141.13 104.61,139.92 107.21,139.92 108.62,138.51 110.49,138.51 110.9,138.1 110.9,137.42 110.52,137.04 110.52,132.94 114.05,129.41 117.36,129.41 v1(117.78,128.98)
  BOTTOM w0.089: U8601.5 166.3,108.97 v1(166.53,108.74)
1D8V_AON_S0: length 259.3
  TOP w0.305: R8608.2 127.08,134.12 v1(127.08,134.37) ; v1(94.36,146.48) 94.49,146.36 C8805.1 U8801.5 ; C8808.1 107.88,143.87 v1(107.19,144.55) 107.19,145.22 106.89,145.52 U8803.5 ; U8804.5 94.33,151.93 93.78,152.48 v1(93.78,152.81) 94.49,153.52 97.06,153.52 v1(97.34,153.24) ; v1(103.71,148.5) 102.87,147.66 R8704.1 ; C8049.1 136.02,125.04 C8036.1 136.28,125.34 v1(135.74,125.89)
  TOP w0.508: 135.74,99.06 135.74,99.06 135.74,98.2 v1(135.03,97.49) ; 135.74,99.06 135.87,99.19 135.87,103.4 v1(135.03,104.24) ; 135.74,99.06 v2(135.72,99.06) ; v1(152.18,107.09) 152.25,107.17 152.25,109.65 v1(151.11,110.79) 151.11,112.27 152.17,113.34 152.28,113.34 152.3,113.36 v1(152.43,113.36) ; v1(130.61,113.03) 130.38,112.8 130.38,112.41 131.06,111.74 131.06,111.73 132.35,110.44 133.15,110.44 v1(133.48,110.1) 133.48,110.11 133.72,110.34 134.31,110.34 136.66,107.99 v1(136.66,105.46)
  L3 w0.508: v1(123.65,129.64) 123.19,130.1 122.18,130.1 121.11,131.17 121.11,132.13 119.03,134.21 119.03,136.65 116.92,138.76 v1(116.34,138.76)
  L3 w0.762: v1(152.43,113.36) 153.9,111.89 153.9,108.6 153.88,108.57 153.88,107.8 154.46,107.21 157.49,107.21 157.62,107.09 158.31,107.09 158.87,107.65 160.96,107.65 161.75,108.43 v1(161.75,108.46)
  L5 w0.508: 132.66,123.65 134.36,125.35 135.17,125.35 135.7,125.89 v1(135.74,125.89) ; 132.66,123.65 132.66,125.84 129.75,128.75 127.66,128.75 ; 132.66,123.65 132.66,119.39 135.89,116.16 143.26,116.16 145.81,113.6 v1(148.09,113.6) 149.21,113.6 149.48,113.34 152.28,113.34 152.3,113.36 v1(152.43,113.36) ; v1(151.11,110.79) 148.79,110.79 v1(148.47,110.47) ; v1(139.86,103.86) 138.41,103.86 137.62,104.65 137.62,104.75 136.9,105.46 v1(136.66,105.46) 136.4,105.46 136.02,105.08 136.02,104.99 135.27,104.24 v1(135.03,104.24) 134.39,104.24 132.87,105.77 v1(132.87,106.86) ; v1(103.71,148.5) 101.5,148.5 98.3,151.7 98.3,152.27 v1(97.34,153.24) ; v1(107.19,144.55) 107.19,143.05 108.46,141.78 108.46,141.28 109.62,140.12 112.18,140.12 113.46,141.4 114.86,141.4 116.34,139.93 v1(116.34,138.76) 114.15,136.58 110.47,136.58 109.92,136.03 108.67,136.03 v1(108.58,136.11)
  L5 w0.762: v1(139.86,103.86) 143.09,107.09 v1(152.18,107.09) 152.18,105.95 155.55,102.58 155.57,102.58 156.09,102.06 156.09,101.3 154.94,100.15 154.94,92.64 157.86,89.71 157.86,83.29 154.39,79.82 v1(151.16,79.82)
  L6 w0.508: v1(94.36,146.48) 97.08,143.77 97.08,141.28 98.4,139.96 99.7,139.96 100,140.26 103.2,140.26 104.45,139.02 105.68,139.02 v1(108.58,136.11) ; v1(123.65,129.64) 125.2,131.19 125.93,131.19 127.13,132.39 127.13,134.32 v1(127.08,134.37) ; v1(107.19,144.55) 107.19,145.09 107.16,145.14 103.85,148.44 v1(103.71,148.5)
  BOTTOM w0.152: v1(148.09,113.6) 148.06,113.63 R7905.1 148.1,114.25 148.86,115.01 R7917.1
  BOTTOM w0.254: v1(133.48,110.1) 133.9,110.52 R7933.1 133.48,111 R7976.1
  BOTTOM w0.305: v1(93.78,152.81) 93.7,152.81 C8806.1 ; v1(139.86,103.86) 139.86,103.44 139.34,102.91 R7922.1 ; U7601.5 135.49,97.1 135.11,97.49 v1(135.03,97.49) 134.98,97.54 R7603.2 ; RN7901.3 148.87,110.77 148.57,110.47 v1(148.47,110.47) 148.22,110.71 RN7901.4 ; GPU1.G12 136.56,126.09 136.42,125.96 136.35,125.96 136.2,125.81 135.82,125.81 v1(135.74,125.89) 135.66,125.81 135.66,125.78 GPU1.G10 ; v1(135.03,104.24) 135.1,104.17 R7931.1 135.07,103.46 R7949.2 133.89,103.46 133.5,103.07 U7602.5
  BOTTOM w0.381: PR8563.1 151.47,79.51 v1(151.16,79.82)
  BOTTOM w0.508: v1(139.86,103.86) R7912.2 ; v1(152.43,113.36) 152.43,114.59 152.17,114.85 152.17,116.99 150.36,118.81 C8004.1 ; Q7906.G 131.92,106.93 132.8,106.93 v1(132.87,106.86)
1D8V_AON_S0_DISCHG: length 2.1
  TOP w0.305: R8704.2 102.01,146.18 v2(101.99,146.16) 101.98,146.16 101.98,145.98 102.44,145.52 Q8701.3
1D8V_AVDD2: length 6.3
  TOP w0.203: 31.19,11.69 31,11.88 30.68,11.88 29.79,12.77 HDA27.33
  TOP w0.508: 31.19,11.69 31.19,11.62 v2(31.77,11.05) 31.78,11.05 31.88,10.95 C2710.1 33.18,11.41 33.71,11.94 R2725.2
1D8V_FBA_PLL_AVDD: length 2.7
  TOP w0.406: v1(138.87,128.43) 138.84,128.4 137.99,128.4 C7809.1
  BOTTOM w0.305: GPU1.H22 v1(141.24,133.18) ; GPU1.F16 v1(138.87,128.43) ; v1(138.83,136.68) GPU1.P22
  vias: v1(135.04,134.14) v1(137.09,133.4) v2(135.77,134.16)
1D8V_GPU_AON_S0:
  vias: v1(167.54,107.85) v2(167.54,109.42)
1D8V_MAIN_EN: length 66.1
  TOP w0.089: R8801.1 99.47,146.78 R8811.2 99.47,145.63 99.57,145.53 v2(99.57,144.83) v1(99.57,144.2)
  L5 w0.089: v1(119,129.13) 119,127.35 133.02,113.34 134.52,113.34 135.49,112.37 v1(135.56,112.37)
  L6 w0.089: v1(99.57,144.2) 100,144.63 102.76,144.63 104.53,142.86 107.11,142.86 109.76,140.22 111.53,140.22 112.36,139.39 116.65,139.39 119.23,136.81 119.23,133.51 119.55,133.2 119.55,129.76 119,129.21 v1(119,129.13)
  BOTTOM w0.089: v1(135.56,112.37) 135.56,112.25 136.25,111.56 R7963.2 136.07,111.53 R7936.2 135.08,110.62 R7933.2 ; D8803.A 100.38,145.01 v1(99.57,144.2) 99.57,144.08 D8801.K 100.47,143.23 R8803.1
1D8V_MAIN_EN_D: length 3.5
  BOTTOM w0.089: v2(97.82,146.48) 97.72,146.38 97.72,145.54 D8803.K 99.14,145.91 R8809.2
1D8V_MAIN_EN_R: length 93.3
  TOP w0.089: v2(101.16,145.27) 101.16,145.28 v1(100.77,145.68) 100.33,146.11 R8811.1 100.43,146.38 C8809.1
  L5 w0.089: v1(166.54,110.01) 165.94,109.41 165.94,108.41 165.29,107.75 162.92,107.75 162.59,107.42 157.68,107.42 157.1,108 155.82,108 153.34,110.48 152.27,110.48 151.92,110.14 148.92,110.14 148.83,110.04 148.1,110.04 147.99,110.16 139.13,110.16 135.47,113.82 132.91,113.82 119.89,126.85 v1(119.89,129.53)
  L6 w0.089: v1(119.89,129.53) 119.89,133.13 119.44,133.57 119.44,136.85 116.72,139.57 112.91,139.57 110.44,142.04 108.19,142.04 107.19,143.04 104.6,143.04 102.83,144.81 101.64,144.81 v1(100.77,145.68)
  BOTTOM w0.089: U8601.3 166.3,109.77 v1(166.54,110.01) ; v1(100.77,145.68) 101.31,145.14 Q8704.2
1D8V_MAIN_ENABLE: length 18.9
  L6 w0.089: v1(133.98,109.71) 135.99,111.72 135.99,115.58 133.72,117.85 133.72,122.77 134.52,123.57 135.28,123.57 v1(135.42,123.71)
  BOTTOM w0.089: v1(135.42,123.71) 135.37,123.75 135.37,124.35 ; R7936.1 134.28,110.01 v1(133.98,109.71) 133.98,109.2 v2(133.91,109.12)
1D8V_S0: length 74
  TOP w0.508: v1(35.08,11.28) R2725.1 ; v1(31.63,6.2) 31.73,6.3 R2709.1
  L3 w0.508: v1(34.29,26.93) 34.29,26.54 35.44,25.4 v1(35.44,19.89)
  L5 w0.508: 33.47,15.83 33.26,15.62 30.75,15.62 30.52,15.85 30.05,15.85 29.42,15.22 29.42,14.05 28.32,12.96 28.32,11.14 30.23,9.24 30.23,7.29 31.03,6.49 31.33,6.49 v1(31.63,6.2) ; 33.47,15.83 35.08,14.21 v1(35.08,11.28) ; 33.47,15.83 35.44,17.8 v1(35.44,19.89)
  L6 w0.508: v1(34.29,26.93) 34.29,27 36.44,29.15 38.95,29.15 40.88,31.08 61.34,31.08 63.15,32.89 63.15,34.01 63.88,34.75 63.88,38.28 62.97,39.19 v1(62.97,40.29)
  vias: v2(62.32,39.25)
1D8V_S0_CT1: length 3.5
  TOP w0.127: v1(61.88,37.8) v2(62.97,37.8) 63.66,37.8 C4011.1
  BOTTOM w0.127: U4004.10 61.45,38.25 61.88,37.82 v1(61.88,37.8)
1D8V_S5: length 172.9
  TOP w0.279: R1515.1 38.55,101.99 v1(38.62,101.99) ; v1(33.91,54.97) 33.83,54.97 R2462.2 32.85,55.5 31.91,54.56 28.76,54.56 28.08,55.24 27.15,55.24 26.66,55.73 25.3,55.73 24.69,56.34 24.69,56.76 24.25,57.2 v1(23.19,57.2) ; v1(37.21,57.13) R2491.2
  L3 w0.305: v1(37.21,57.13) 35.37,57.13 33.86,55.62 33.86,55.02 v1(33.91,54.97)
  L3 w0.762: v1(166.37,106.2) 162.31,106.2 159.36,103.25 159.36,102.67 158.27,101.58 158.27,97.72 163.22,92.76 163.22,85.42 164.29,84.35 164.29,78.68 166.18,76.79 166.91,76.79 168.89,74.8 168.89,73.89 169.8,72.98 169.8,72.02 v1(172.32,69.5)
  L5 w0.152: v1(38.62,101.99) 39.12,101.49 39.12,94.58 40.38,93.32 40.38,77.23 36.46,73.31 36.25,73.31 34.11,73.31 32.22,71.43 32.22,70.16 31.14,69.08 31.14,68.39 30.45,67.7 29.33,67.7 28.63,66.99 28.63,65.94 26.8,64.11 26.8,60.28 24.69,58.17 24.16,58.17 v1(23.19,57.2)
  L5 w0.305: v1(29.67,45.67) 30.02,45.67 30.76,44.93 30.76,44.35 32.17,42.94 56.43,42.94 57.13,42.24
  BOTTOM w0.305: v1(29.67,45.67) 28.78,45.67 27.07,47.38 27.07,55.08 26.84,55.31 26.84,55.38 26.26,55.96 25.36,55.96 24.13,57.19 23.37,57.19 23.36,57.2 v1(23.19,57.2) 21.95,57.2 21.54,57.61 21.54,58.45 20.04,59.95 R2497.2
  vias: v1(57.33,41.61) v1(57.97,41.61) v1(58.6,41.58) v1(59.26,41.58) v1(125.6,65.71) v1(161.62,69.65) v2(58.17,40.39) v4(98.58,52.4) v4(99.24,51.74) v4(101.04,43.51) v4(101.07,44.35) v4(124.87,65.81) v4(162.61,61.85) v4(163.45,61.85)
1D8V_VCCPRIM: length 84.8
  TOP w0.508: v1(109.93,89.79) 109.97,89.79 R2113.1
  TOP w1.016: 116.72,92.46 119,90.17 119,89.5 v4(119.19,89.31)
  L5 w0.381: v4(139.25,73.33) 159.57,73.33 v4(159.66,73.43)
  L5 w1.016: 124.49,67.7 117.37,74.81 117.37,81.69 116.57,82.49 116.57,85.24 118.49,87.16 118.49,88.61 v4(119.19,89.31)
  BOTTOM w0.114: R1512.1 101.91,77.39 112.84,66.46 116.46,66.46 116.72,66.72 116.72,67.11 116.98,67.37 117.38,67.37 117.88,66.87 125.92,66.87 126.75,66.04 v4(126.75,65.8)
  BOTTOM w0.152: CPU1.CP23 114.16,92.65 v1(114.2,92.69)
  BOTTOM w0.254: v1(113.77,96.32) 113.74,96.32 113.63,96.43 CPU1.CP17
  vias: v1(106.56,97.31) v1(107.22,96.5) v1(107.22,95.66) v2(107.67,96.09) v2(111.26,97.33) v2(115.6,92.48) v2(128.3,66.32) v2(132.29,70.87) v2(137.95,71.96)
1D8V_VGA_DISC: length 3.5
  BOTTOM w0.089: Q8704.6 104.28,144.49 R8708.1 ; R8708.1 103.66,145.14 Q8704.5 ; R8708.1 105.11,145.31 v2(105.2,145.31)
1D8V_VGA_PLL: length 10.1
  TOP w0.508: R8003.1 137.72,120.4 137.42,120.7 v2(137.11,120.7) 136.66,120.24 136.66,119.53 136.22,119.1 135.16,119.1 132.59,121.67 132.59,122.91
  BOTTOM w0.305: v1(130.64,124.97) 130.62,124.99 GPU1.L6 130.04,125.51 v1(130.03,125.5)
1D8V_VGA_S0: length 86.4
  TOP w0.305: R8810.1 97.16,148.69 98.3,147.55 v1(98.3,147.52) ; v1(127.66,134.93) 127.66,134.62 R8607.2 128.53,134.91 R8605.2
  TOP w0.356: v1(150.24,109.35) v2(149.56,109.48)
  L3 w0.635: v1(127.66,134.93) 127.75,134.84 127.75,132.92 126.8,131.97 122.64,131.97 120.55,134.06 120.55,136.35 117.31,139.59 114.24,139.59 v1(113.77,140.06)
  L6 w0.508: v1(134.71,98.99) 136.05,98.99 140.67,103.61 140.67,104.94 142.24,106.51 142.24,108.92
  L6 w0.635: v1(127.66,134.93) 128.2,134.39 128.2,133.22 ; v1(113.77,140.06) 113.11,140.06 110.62,142.55 108.66,142.55 107.62,143.59 104.74,143.59 102.67,145.66 102.67,145.95 101.1,147.52 v1(98.3,147.52) ; 152.48,110.62 154.31,112.45 159.52,112.45 160.63,111.33 v1(161.7,111.33)
  BOTTOM w0.254: R7946.2 158.68,112.9 159.35,112.23 159.35,112.01 160.03,111.33 v1(161.7,111.33)
  BOTTOM w0.305: v1(150.24,109.35) 150.22,109.37 Q7901.5 ; v1(146.69,109.35) 146.71,109.37 Q7901.2
  BOTTOM w0.356: GPU1.G8 134.21,124.32 v1(134.79,124.32) 134.79,124.9 GPU1.G9
  BOTTOM w0.508: v1(134.71,98.99) 134.45,98.99 134.03,99.4 Q7601.G ; v1(98.3,147.52) 102.44,147.52 102.82,147.14 R8707.1
  vias: v4(138.31,119.05) v4(139.02,118.29)
1D8V_VGA_S0_DISCHG: length 2.2
  BOTTOM w0.305: v2(100.94,146.91) 101.87,146.91 R8707.2 101.96,146.38 101.63,146.05 Q8704.3
1D24V_VCCDPHY_EC: length 2.7
  TOP w0.508: C2218.1 114.25,91.26 v1(114.28,91.23) 114.3,91.21 114.79,91.21 114.79,91.21 v2(114.84,91.21)
  BOTTOM w0.254: CPU1.CP25 113.21,91.31 114.2,91.31 v1(114.28,91.23)
1D35V_PGOOD: length 105.5
  TOP w0.089: v1(97.74,142.5) 97.55,142.5 97.21,142.15 97.21,141.56 97.52,141.25 U8802.2 ; v1(119.84,134.55) 119.49,134.19 119.49,128.39 125.12,122.76 125.12,120 128.98,116.13 128.98,113.03 132.41,109.6 v2(132.67,109.6) 132.78,109.6 134.2,108.19 134.2,103.84 134.68,103.35 134.68,99.94 v1(134.6,99.86)
  L5 w0.089: v1(114.94,140.29) 113.92,139.27 108.16,139.27 106.13,141.3 106.13,145.24 107.27,146.39 107.27,148.44 107.73,148.9 107.75,148.9 108.27,149.42 108.27,152.63 107.08,153.82 106.43,153.82 v1(105.54,154.71) 104.7,155.55 97.11,155.55 96.39,154.83 96.39,147.73 96.57,147.55 96.57,144.13 97.74,142.95 v1(97.74,142.5)
  L6 w0.089: v1(114.94,140.29) 115.32,139.9 116.77,139.9 119.84,136.83 v1(119.84,134.55)
  BOTTOM w0.089: v1(134.6,99.86) 134.64,99.86 135.4,99.1 U7302.2 ; v1(105.54,154.71) 105.79,154.46 105.79,153.07 106.3,152.56 PR8630.1
1D35V_PWR:
  vias: v2(118.11,146.99) v4(118.24,149.08) v4(119.13,149.07) v4(119.99,149.07)
1D35V_VGA_EN#: length 4.1
  TOP w0.089: Q8702.6 106.17,150.94 105.78,151.32 R8705.1 ; R8705.1 105.54,151.74 105.36,151.56 105.36,150.9 v2(105.46,150.8) ; R8705.1 106.23,151.74 106.38,151.59 Q8702.5
1D35V_VGA_S0: length 273.5
  TOP w0.089: 158.91,117.43 159.64,117.43 ; 157.21,117.47 157.21,119.01 ; 141.21,130.18 140.81,129.78 140.81,129.76 ; 141.21,130.18 140.78,130.61 ; 141.21,130.18 141.68,129.7 ; 141.21,130.18 141.23,130.18 141.79,130.73 ; 162,149.22 162,148.57 ; 156.4,139.64 156.4,139 ; 138.42,127.14 138.87,126.68 ; 138.87,126.68 139.94,125.62 ; 138.87,126.68 138.46,126.27 138.44,126.27 ; 138.87,126.68 139.45,127.26 139.45,127.26 ; 163.6,148.54 163.38,148.54 163.37,148.53 162.91,148.53 ; 163.6,148.54 163.6,147.96 163.58,147.94 ; 163.6,148.54 163.82,148.54 163.83,148.53 164.17,148.53 164.18,148.54 165.2,148.54 ; 163.6,148.54 163.6,148.76 163.6,149.1 163.6,149.1 163.6,149.25 ; 164.37,118.21 164.62,118.21 164.63,118.23 165.03,118.23 ; 164.37,118.21 164.37,117.52 ; 164.37,118.21 164.37,118.44 164.4,118.47 164.4,119.06 ; 157.99,148.52 157.99,149.3 ; 162.8,141.33 162.8,141.1 162.8,140.52 ; 162.8,141.33 162.8,142.21 ; 162.8,141.33 162.57,141.33 162.57,141.33 162.06,141.33 ; 162.8,141.33 163.04,141.33 163.04,141.33 164.24,141.33 ; v1(141.23,131.98) 141.28,131.93 141.99,131.93 142.26,131.65 142.26,131.23 141.98,130.95 141.98,130.92 141.79,130.73 ; 165.18,120.63 164.47,120.63 ; 166.7,124.61 166.04,124.61 ; 164.4,124.73 164.4,125.43 164.4,125.43 164.4,126 ; 165.28,147.88 165.2,147.96 165.2,148.54 ; 154.8,148.29 154.56,148.53 154.23,148.53 153.98,148.79 153.98,149.23 ; 154.8,148.29 154.8,147.96 154.79,147.95 154.79,147.73 ; 154.8,148.29 154.8,148.29 155.03,148.53 155.35,148.53 155.6,148.77 155.6,149.27 ; 141.89,126.31 141.89,126.31 142.15,126.57 142.15,126.57 142.32,126.74 142.35,126.74 142.93,127.32 ; 163.58,127.03 163.58,126.32 163.49,126.23 ; 163.58,127.03 163.58,127.71 ; 163.58,127.03 163.82,127.03 163.82,127.03 164.15,127.03 164.29,127.03 ; 141.64,128.31 141.37,128.04 141.37,128.04 141.18,127.86 140.77,127.44 ; 166.8,146.92 166.8,147.66 166.73,147.73 166.12,147.73 ; 165.91,127.03 165.33,127.03 ; 166.83,119.08 166.83,119.76 ; 141.79,130.73 141.95,130.58 141.97,130.58 142.24,130.31 142.25,130.31 142.39,130.17 ; 141.79,130.73 141.31,131.22 ; 138.89,125.51 138.42,125.97 ; 138.89,125.51 138.85,125.51 138.38,125.03 ; 138.89,125.51 139.44,124.95 ; 166.68,148.54 166.58,148.54 166.57,148.53 166.23,148.53 166.22,148.54 166,148.54 ; 164.39,141.99 164.39,141.48 164.24,141.33 ; 139.45,127.26 138.98,127.73 ; 139.45,127.26 140.03,127.84 ; 139.45,127.26 139.88,126.84 ; 164.24,141.33 164.4,141.17 164.4,140.76 164.39,140.75 164.39,140.56 ; 166.68,125.43 166.04,125.43 ; 154.8,140.45 154.8,139.84 ; 142.39,130.17 142.38,130.17 141.94,129.74 ; 142.39,130.17 142.87,129.69 ; 166.8,117.57 166.8,118.23 ; 139.98,124.41 139.44,124.95 ; 139.44,124.95 138.9,124.4 ; 156.4,126.27 156.4,126.8 156.63,127.03 157.05,127.03 ; 140.03,127.84 139.6,128.28 ; 140.03,127.84 140.2,128.01 140.2,128.02 140.44,128.26 140.61,128.43 ; 140.03,127.84 140.51,127.36 ; 156.42,148.52 156.42,147.99 156.39,147.96 156.39,147.75 ; 156.42,148.52 157.2,148.52 ; 156.42,148.52 156.42,149.22 ; 162.8,148.65 162.8,149.29 ; 164.39,127.18 164.39,127.81 ; 166,149.4 166,148.54 ; 166,148.54 166,147.96 166.07,147.9 ; 162.76,126.23 163.49,126.23 ; 163.49,126.23 163.6,126.11 163.6,125.67 163.6,125.66 163.6,125.55 163.48,125.43 ; 162.79,118.34 162.79,119 ; 157.2,139.07 157.2,139.75 ; 157.2,139.75 157.43,139.75 157.43,139.75 157.84,139.75 ; 157.2,139.75 157.2,139.98 157.2,139.98 157.2,140.43 ; 143.51,126.7 143.09,126.28 ; 158.02,118.19 158.02,117.48 ; 154.82,126.29 154.82,126.45 154.8,126.46 154.8,127.86 ; 163.48,125.43 163.6,125.31 163.6,124.71 ; 163.48,125.43 162.82,125.43 ; 155.63,127.76 155.63,126.83 155.6,126.8 155.6,126.24 ; 164.29,147.73 163.68,147.73 ; 161.8,149.31 161.2,149.31 ; 166.1,119.83 166.67,119.83 ; 167.61,141.35 166.78,141.35 ; 156.4,118.99 156.4,117.41 ; 139.34,128.33 138.99,127.98 ; 158.01,139.03 158.01,139.66 ; 162.82,139.68 162.82,139.02 ; 165.2,140.61 165.2,141.35 ; 158,141.39 158,142.08 ; 165.2,138.99 165.2,139.73 ; 165.2,118.27 165.2,118.98 ; 159.97,138.13 159.97,138.79 ; 165.2,148.54 165.2,149.33 ; 141.86,128.35 142.31,127.9 ; 166.8,124.74 166.8,125.3 ; 139.51,123.88 139.93,124.3 ; 157.2,142.06 157.2,141.46 ; 165.2,127.11 165.2,127.74 ; 166.8,149.33 166.8,148.65 ; 164.39,139.75 164.39,138.94 ; 166.85,140.51 167.57,140.51 ; 167.55,139.71 166.87,139.71
  TOP w0.102: 142.98,126.09 141.36,127.7 141.34,127.7 140.21,128.83 ; 140.81,129.43 141.07,129.17
  TOP w0.508: v1(113.49,146.56) 113.49,147.83 110.57,150.75 R8709.1
  L3 w0.305: v1(156.8,120.23) 156.8,120.11 ; v1(155.2,120.23) 155.2,120.07
  L5 w0.089: 163.43,126.23 163.6,126.06 163.6,125.63 163.5,125.53 163.5,125.43 ; 163.43,126.23 163.58,126.39 163.58,127.7 ; 163.43,126.23 162.99,126.23 ; 141.29,134.87 141.78,134.37 141.78,134.36 ; 163.5,125.43 162.98,125.43 ; 163.5,125.43 163.6,125.33 ; 163.6,124.74 163.6,125.33 ; 163.6,125.33 163.74,125.33 163.83,125.43 164.17,125.43 164.17,125.43 164.4,125.43 ; 166.08,119.83 166.68,119.83 ; 159.64,119.03 160.4,119.03 160.4,119.03 ; 160.4,118.38 160.4,119.03 ; 160.4,119.03 160.4,119.72 ; 160.4,119.03 160.63,119.03 160.63,119.03 161.21,119.03 ; 162.98,148.53 163.37,148.53 163.38,148.54 163.6,148.54 ; 164.39,118.24 164.39,118.46 164.4,118.47 164.4,118.94 ; 164.39,118.24 164.63,118.24 164.63,118.23 165.09,118.23 ; 164.39,118.24 164.39,117.64 ; 164.39,139.56 164.39,139.09 ; 164.35,147.73 163.78,147.73 ; 164.4,127.21 164.4,127.72 ; 167.74,127.43 167.05,127.43 ; 167.48,124.61 166.92,124.61 ; 166.8,147.5 166.8,147.06 ; 164.4,126.15 164.4,125.43 ; 164.4,125.43 164.4,125.2 164.4,125.2 164.4,124.58 ; 165.87,127.03 165.38,127.03 ; 159.79,128.53 159.79,128.15 ; 166.8,117.55 166.8,118.16 ; 161.87,149.31 161.35,149.31 ; 142.21,134.8 142.21,134.79 141.78,134.36 ; 141.78,134.36 141.35,133.93 ; 161.98,149.12 161.98,148.64 ; 162.79,118.34 162.79,118.95 ; 165.2,120.63 164.39,120.63 ; 166.14,125.42 166.73,125.42 ; 162.8,139.02 162.8,139.6 ; 162.8,125.42 162.8,124.72 ; 165.2,118.95 165.2,118.35 ; 160.63,128.52 160.63,128.17 ; 166,149.28 166,147.78 ; 165.2,149.22 165.2,147.83 ; 165.2,140.65 165.2,141.19 165.35,141.34 ; 162.8,148.62 162.8,149.22 ; 165.2,127.76 165.2,127.11 ; 167.66,126.63 167.04,126.63 ; 163.6,148.54 163.6,148.76 163.6,149.28 ; 163.6,148.54 163.6,147.8 ; 166.84,119.64 166.84,119.21 ; 166.63,124.61 166.04,124.61 ; 166.8,149.22 166.8,148.58 ; 139.36,135.46 139.01,135.11 ; 166.81,124.76 166.81,125.23 ; 166.2,147.71 166.65,147.71 ; 159.6,125.36 159.6,124.71 ; 142.5,134.82 142.8,134.52 ; 165.2,139.03 165.2,139.65
  L5 w0.102: 141.09,134.81 140.74,134.45 ; 143.96,135.34 143.6,134.99 ; 139.61,135.4 139.91,135.09 ; 140.49,135.39 140.18,135.08
  L5 w0.508: v4(121.96,145.82) 121.9,145.82 121.87,145.85 114.2,145.85 v1(113.49,146.56)
  L6 w0.089: 164.38,139.55 164.38,139.02 ; 167.02,140.52 167.5,140.52 ; 162.8,148.64 162.8,149.26 ; 164.37,117.66 164.37,118.07 164.53,118.23 ; 164.4,125.43 164.4,125.2 164.4,125.2 164.4,124.7 ; 164.4,125.43 164.4,126.13 ; 164.4,125.43 164.17,125.43 164.17,125.43 163.7,125.43 163.6,125.33 ; 166.8,117.6 166.8,118.14 ; 163.5,125.43 163.5,125.57 163.6,125.66 163.6,126.06 163.43,126.23 ; 163.5,125.43 163.6,125.33 ; 163.5,125.43 162.98,125.43 ; 164.4,118.96 164.4,118.36 164.53,118.23 ; 163.61,127.69 163.61,127.61 163.58,127.59 163.58,126.39 163.43,126.23 ; 165.38,141.34 165.2,141.15 165.2,140.5 ; 160.4,119.66 160.4,119.03 ; 160.4,119.03 160.4,118.8 160.4,118.8 160.4,118.41 ; 160.4,119.03 160.63,119.03 160.63,119.03 161.14,119.03 ; 160.4,119.03 160.17,119.03 160.17,119.03 159.62,119.03 ; 162.79,118.41 162.79,118.93 ; 166,149.23 166,147.78 ; 141.79,134.37 141.63,134.53 141.63,134.53 141.37,134.79 141.37,134.8 ; 141.79,134.37 141.96,134.2 141.96,134.2 142.36,133.8 142.36,133.77 ; 141.79,134.37 141.33,133.91 ; 141.79,134.37 142.28,134.86 ; 167.04,126.63 167.68,126.63 ; 159.8,128.55 159.8,128.14 ; 162.83,148.53 163.44,148.53 ; 163.44,148.53 163.6,148.37 163.6,147.72 ; 163.44,148.53 163.6,148.69 163.6,148.76 163.6,149.36 ; 163.43,126.23 162.91,126.23 ; 167.72,127.43 167,127.43 ; 163.6,125.33 163.6,124.62 ; 166.13,147.71 166.73,147.71 ; 161.98,148.68 161.98,149.13 ; 165.1,118.23 164.53,118.23 ; 167.44,141.34 166.87,141.34 ; 165.2,139.75 165.2,139.05 ; 166.18,124.61 166.65,124.61 ; 166.16,125.43 166.72,125.43 ; 162.82,139.67 162.82,139.02 ; 165.2,149.27 165.2,147.83 ; 162.8,125.32 162.8,124.75 ; 164.38,127.67 164.38,127.23 ; 166.84,119.15 166.84,119.64 ; 161.89,149.31 161.25,149.31 ; 166.81,125.23 166.81,124.79 ; 165.2,127.77 165.2,127.12 ; 140.17,135.99 140.5,135.66 ; 166.8,148.64 166.8,149.2 ; 159.6,125.39 159.6,124.77 ; 165.03,120.63 164.52,120.63 ; 167.57,124.62 166.97,124.62 ; 160.66,128.55 160.66,128.11 ; 166.72,119.83 166.14,119.83 ; 139.03,135.13 139.37,135.47 ; 165.89,127.03 165.3,127.03 ; 165.2,118.94 165.2,118.34 ; 166.99,139.69 167.57,139.69
  L6 w0.102: 143.42,133.64 142.51,132.73 ; 140.46,135.38 140.16,135.08 ; 139.61,135.4 139.92,135.09 ; 141.09,134.82 140.73,134.46 ; 141.28,133.73 141.68,133.33
  L6 w0.127: 143.99,135.38 143.6,134.98 ; 142.81,134.23 141.94,133.35 ; 145.36,131.88 145.67,131.57
  BOTTOM w0.102: VRAM4.G13 161.99,148.54 161.99,149.32 VRAM4.G14
  BOTTOM w0.203: GPU1.B26 148.62,131.98 v1(148.72,131.88) ; VRAM1.T3 165.59,125.82 165.59,125.02 VRAM1.R5
  BOTTOM w0.25: GPU1.L26 142.57,137.22 143.37,138.03 v1(143.37,138.07)
  BOTTOM w0.305: VRAM4.T12 155.2,147.33 v1(155.2,147.33) ; v1(164,121.03) VRAM1.N10 164.01,120.22 v1(164.04,120.22) 164.04,120.19 VRAM1.P11 164.4,119.83 v1(164.8,119.43) 164.4,119.03 VRAM1.P12 ; VRAM4.L4 158.44,140.97 v1(158.44,140.93) ; v1(156.8,140.93) VRAM4.P3 v1(156,140.13) ; v1(165.61,141.73) 165.2,142.13 VRAM4.C5 ; VRAM1.L14 162,116.87 v1(162,116.86) ; VRAM1.C10 v1(155.2,120.23) ; v1(162.07,138.39) 162,138.46 VRAM4.G1 ; VRAM4.G11 161.96,146.93 v1(161.57,147.32) 161.2,147.69 VRAM4.H12 v1(161.6,148.13) VRAM4.G13 VRAM4.F12 163.21,147.32 v1(163.22,147.32) ; VRAM4.B1 166.11,138.82 v1(166.11,138.35) 166.17,138.3 ; VRAM4.M3 158.38,140.15 v1(158.42,140.15) 158.42,140.11 VRAM4.L2 ; v1(158.43,117.03) 158.43,117.04 158.8,117.41 VRAM1.G14 ; v1(162,128.36) VRAM1.L1 162.4,127.43 v1(162.4,127.43) 162,127.03 VRAM1.L2 ; GPU1.G16 138.33,128.99 v1(138.31,128.97) GPU1.G15 ; GPU1.H24 143.53,134.34 v1(143.54,134.33) ; VRAM4.H3 v1(161.6,140.93) VRAM4.G4 ; v1(157.61,142.55) 157.2,142.14 VRAM4.N5 ; VRAM4.F14 v1(163.18,149.71) ; v1(166.35,149.77) 166.35,149.68 VRAM4.B14 ; VRAM1.R10 v1(165.6,120.23) ; v1(138.28,127.83) 138.28,127.83 GPU1.F14 ; v1(164.47,128.37) 164.47,127.9 VRAM1.P1 ; VRAM4.E5 v1(163.2,142.53) ; VRAM4.L13 v1(159.2,148.13) VRAM4.K12 ; VRAM1.M3 v1(162.4,125.83) VRAM1.L4 v1(161.6,125.83) VRAM1.K3 v1(160.8,125.83) ; R7824.2 v1(161.34,135.99) ; VRAM4.M12 157.62,148.11 v1(157.6,148.11) ; v1(154.42,125.82) 154.8,126.19 VRAM1.B3 ; VRAM1.T12 v1(165.6,119.43) ; VRAM4.D1 v1(164.4,138.4) ; GPU1.N21 v1(138.31,134.98) ; VRAM4.B12 166,147.73 v1(165.61,147.33) ; GPU1.M21 v1(138.88,134.41) ; GPU1.G21 v1(141.23,131.98) ; VRAM1.D14 v1(156,117.03) ; v1(157.2,124.1) 156.13,124.1 VRAM1.C5 v1(155.2,125.03) ; VRAM4.P1 v1(156.4,138.4) ; v1(158.08,149.86) 158,149.78 VRAM4.M14 ; VRAM1.P14 164.4,117.05 v1(164.24,116.89) ; v1(162.8,116.86) 162.8,116.87 VRAM1.M14 ; VRAM1.G4 v1(159.2,125.83) ; VRAM4.L14 158.8,149.73 v1(158.93,149.86) ; VRAM4.C10 v1(165.6,146.53) ; VRAM4.F3 162.8,140.53 v1(162.41,140.14) 162,139.73 VRAM4.G2 ; v1(160,140.93) VRAM4.K3 v1(159.2,140.93) ; VRAM4.L11 v1(159.2,147.33) ; v1(165.92,116.86) 165.92,116.86 166,116.94 VRAM1.T14 ; VRAM1.G13 v1(159.2,118.63) VRAM1.H12 v1(159.2,119.43) VRAM1.G11 ; VRAM4.R10 v1(155.22,146.51) ; VRAM4.D3 v1(164,140.13) ; VRAM4.M1 158,138.54 v1(157.84,138.38) ; v1(144.73,132) 144.13,132 GPU1.E23 ; VRAM4.G14 v1(162.38,149.71) ; VRAM1.P3 164.4,126.23 v1(164.79,126.62) ; VRAM1.F12 157.63,119.4 157.63,119.41 v1(157.6,119.43) ; v1(158.03,128.37) 158,128.34 VRAM1.F1 ; VRAM4.D12 v1(164.8,147.33) VRAM4.D11 164,146.53 v1(163.96,146.53) 163.96,146.49 VRAM4.E10 ; VRAM1.B14 v1(154.4,117.03) ; VRAM1.G1 v1(158.4,127.43) VRAM1.G2 ; v1(158.71,138.38) 158.71,138.84 VRAM4.L1 ; VRAM4.R5 v1(155.2,142.53) ; v1(155.2,139.33) VRAM4.T1 154.65,138.78 v1(154.65,138.37) ; v1(166.4,126.63) 166,126.23 VRAM1.T3 ; VRAM1.H3 v1(160,125.83) ; v1(156.52,128.37) 156.4,128.26 VRAM1.D1 ; v1(156,125.83) 156.4,126.23 VRAM1.D3 ; VRAM1.F3 v1(158.4,126.63) ; VRAM4.F1 162.8,138.48 v1(162.89,138.39) ; GPU1.J21 v1(140.63,133.77) ; GPU1.T21 v1(136.56,136.73) ; VRAM4.B3 v1(166.4,140.93) ; GPU1.G18 140.07,130.69 v1(140.03,130.72) 140.05,130.75 GPU1.G19 140.63,131.36 v1(140.64,131.37) 140.65,131.38 GPU1.G20 ; R7816.2 v1(161.34,130.61) ; VRAM4.P12 v1(156,147.33) VRAM4.P11 156.4,146.9 v1(156.79,146.51) 156.81,146.49 156.84,146.49 VRAM4.N10 ; v1(135.37,137.92) GPU1.V21 ; v1(157.63,117.04) 158,117.41 VRAM1.F14 ; GPU1.K21 v1(140.07,134.34) ; v1(144.71,136.1) 144.08,135.47 GPU1.H26 ; v1(154.67,128.38) 154.8,128.25 VRAM1.B1 ; VRAM1.N5 v1(163.2,124.23) ; VRAM1.K12 v1(161.62,118.61) VRAM1.L13 ; v1(163.2,119.43) VRAM1.M12 VRAM1.L11 v1(162.4,120.23) ; VRAM1.T1 v1(166,128.39) ; VRAM4.T3 v1(155.2,140.93) ; VRAM4.T14 v1(154.8,149.89) ; VRAM1.E10 v1(156.8,120.23) VRAM1.D11 v1(156,119.43) VRAM1.D12 ; VRAM1.R5 v1(165.6,124.23) ; v1(134.8,138.43) GPU1.W21 ; VRAM1.M1 v1(162.8,128.36) ; VRAM4.D14 v1(164.02,149.71) ; VRAM1.B12 v1(155.2,119.43) ; GPU1.R21 v1(137.12,136.17)
  BOTTOM w0.356: GPU1.L24 141.19,136.09 v1(141.19,135.53) ; GPU1.E26 146.03,133.71 146.83,134.51 v1(146.83,134.56) ; GPU1.C25 GPU1.B26
  vias: v1(156.4,149.92) v1(156.8,145.71) v1(157.59,127.42) v1(158.4,148.14) v1(159.21,148.92) v1(160.8,125.03) v1(162.42,117.83) v1(166.64,144.49) v2(123.57,146.48) v2(163.22,135.31) v2(163.91,133.73) v2(163.91,131.37) v2(165.15,135.03) v2(167.21,135.38) v4(121.96,148.34) v4(121.96,147.5) v4(121.96,146.66) v4(122.8,148.34) v4(122.8,147.5) v4(122.81,146.66) v4(123.59,148.07) v4(123.61,147.22) v4(136.53,150.04) v4(137.25,150.71) v4(145.55,154.61) v4(146.43,154.61) v4(147.32,154.61) v4(148.34,154.61)
1D35V_VGA_S0_DISCHG: length 2.4
  TOP w0.305: R8709.2 110.37,151.93 109.95,152.35 v2(109.73,152.35) 109.25,152.35 109.14,152.24 Q8702.3
2D5V_S3: length 103.9
  TOP w0.305: v1(97.21,49.58) 97.06,49.43 C1207.1 97.13,48.95 C1231.1
  TOP w0.508: PR5122.1 PR5121.1 92.43,39.22 92.43,40.74 93.15,41.45 v2(93.81,41.45) v1(94.77,41.45)
  L3 w0.508: v1(94.77,41.45) 95.76,41.45 98.07,43.77 98.07,45.02 99.27,46.21 99.27,47.52 v1(97.21,49.58)
  L5 w0.508: v1(97.21,49.58) 98.1,48.69 105.39,48.69 v1(105.71,48.38)
  BOTTOM w0.279: v1(97.21,49.58) 96.6,49.58 96.33,49.86 DM1.257
  BOTTOM w0.305: DM1.259 96.83,49.97 v1(97.21,49.58)
  BOTTOM w0.508: 173,52.73 172.6,53.14 142.04,53.14 141.33,53.85 133.28,53.85 132.58,53.15 127.27,53.15 126.48,52.36 106.19,52.36 105.71,51.87 v1(105.71,48.38)
  vias: v1(172.72,49.63)
3D3V_AON_1D8V_VGA_S0: length 5.2
  TOP w0.305: v2(125.89,133.73) 125.89,133.22 v1(125.96,133.15)
  TOP w0.508: v1(126.52,132.64) 126.52,131.93 R7616.2 ; v1(126.52,132.64) 126.47,132.64 v1(125.96,133.15) ; v1(126.52,132.64) 126.75,132.41 127.31,132.41 C7616.1 128.02,133.12 R8608.1 R8607.1
3D3V_AUX_S5: length 336.3
  TOP w0.254: R1726.2 159.32,69.14 159.32,71.98 158.37,72.93 v2(158.37,73.53) 158.37,75.19 157.83,75.73 R1737.1 v1(156.76,76.53) ; AFTP6402.1 210.06,58.12 210.06,57.55 210.49,57.13 v1(210.57,57.13)
  TOP w0.508: v1(136.58,103.07) 136.81,103.07 137.42,103.68 137.42,108.31 134.52,111.2 v2(133.05,111.2) 132.67,111.2 131.98,111.89 v1(131.85,111.89) ; v1(125.72,118.61) 125.62,118.61 124.56,119.66 124.56,122.53 118.75,128.35 117.05,128.35 v1(116.72,128.68) ; v1(155.2,101.7) 155.21,101.68 155.22,101.68 157.25,99.65 v2(157.25,98.31) 158.99,96.57 158.99,94.08 R2505.1 ; v1(51.69,134.21) 54.32,134.21 55.38,135.27 v2(55.38,135.32) 55.54,135.49 55.54,135.5 58.01,137.96 60.95,137.96 61.9,137.01 v1(61.9,136.53)
  L3 w0.508: v1(28.93,96.7) 28.93,96.69 28.6,96.36 28.6,96.32 28.55,96.27 28.55,94.14 30.63,92.06 38.77,92.06 39.27,91.56 39.27,77.6 37.31,75.64 35.78,75.64 35.41,75.27 35.41,74.83 35.35,74.77 35.35,74.75 34.3,73.7 29.42,73.7 29.26,73.53 28.16,73.53 27.79,73.16 27.79,72.51 v1(27.96,72.34) ; v1(61.9,136.53) 61.9,137.57 64.57,140.23 67.08,140.23 69.37,142.52 85.14,142.52 85.37,142.29 85.98,142.29 87.4,143.71 87.4,144.5 87.9,144.99 88.61,144.99 88.8,144.81 91.42,144.81 92.46,145.85 94.63,145.85 95.37,146.59 95.37,147.99 98.2,150.83 v1(98.2,153.29)
  L5 w0.508: v1(28.93,96.7) 28.93,98.76 27.05,100.64 26.01,100.64 25.15,101.5 25.15,102.92 25.53,103.3 25.53,108.26 24.95,108.84 24.95,120.52 24.07,121.4 24.07,123.49 31.95,131.37 35.11,131.37 36.15,132.41 36.15,133 36.91,133.76 44.28,133.76 47.98,130.05 49.61,130.05 51.69,132.13 v1(51.69,134.21) ; v1(132.39,102.49) 133.15,103.25 136.4,103.25 v1(136.58,103.07) 136.76,103.25 137.94,103.25 138.09,103.1 139.37,103.1 139.5,102.97 140.23,102.97 140.51,103.25 140.57,103.25 143.45,106.14 150.74,106.14 155.2,101.68 v1(155.2,101.7) ; v1(98.2,153.29) 99.51,154.6 102.71,154.6 104.37,152.93 104.37,148.26 105.03,147.6 105.03,145.47 104.42,144.86 104.42,140.06 107.6,136.88 109.09,136.88 v1(109.17,136.79)
  L6 w0.254: v1(158.12,82.37) 159.33,82.37 161.52,84.56 161.52,86.64 160.71,87.45 160.71,88.6 161.27,89.16
  L6 w0.508: v1(131.85,111.89) 132.24,112.27 132.24,114.05 127.46,118.82 125.93,118.82 v1(125.72,118.61) ; v1(162.28,88.01) 162.28,88.14 160.25,90.17 157.74,90.17 154.99,92.91 154.99,101.49 v1(155.2,101.7) ; v1(116.72,128.68) 112.88,128.68 112.73,128.83 112.72,128.83 109.73,131.81 109.73,136.23 v1(109.17,136.79)
  BOTTOM w0.152: v1(210.57,57.13) 210.57,56.69 C6401.2 211.01,56.62 PWR1.1
  BOTTOM w0.254: v1(156.76,76.53) 156.85,76.62 156.85,77.8 157.46,78.41 v2(157.46,79.91) 157.46,81.89 157.94,82.37 v1(158.12,82.37)
  BOTTOM w0.305: R2463.1 27.77,72.53 v1(27.96,72.34) ; PG4532.2 62.16,132.82 62.16,135.21 PR4505.1 62.31,135.53 61.9,135.94 v1(61.9,136.53)
  BOTTOM w0.508: R7952.2 132.43,102.53 132.39,102.49 v1(132.39,102.49)
