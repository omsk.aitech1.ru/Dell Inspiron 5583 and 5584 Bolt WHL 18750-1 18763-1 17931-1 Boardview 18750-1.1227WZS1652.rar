# Allegro board 18750-1.1227WZS1652.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_A16: length 53.1
  L5 w0.14: v1(70.57,45.05) 71.03,45.51 71.03,47.72 71.31,48.01 71.31,50.26 83.89,62.83 83.89,80.74 83.9,80.75 83.9,82.39 83.65,82.64 83.3,82.64 83.08,82.86 83.08,83.51 82.69,83.9 81.94,83.9 80.58,85.26 80.58,85.8 80.41,85.98 80.41,86.36 80.35,86.41 80.35,86.76 80.41,86.81 80.41,86.9 v1(80.75,87.25)
  BOTTOM w0.14: v1(70.57,45.05) 70.27,45.05 70.08,44.85 DM1.152 ; v1(80.75,87.25) 80.35,86.85 CPU1.Y32
M_A_ACT_N: length 55.6
  L5 w0.14: v1(57.59,45.64) 56.7,45.64 56.57,45.77 56.57,46.19 56.71,46.33 57.55,46.33 57.69,46.47 57.69,46.75 57.55,46.89 56.71,46.89 56.57,47.03 56.57,49.02 56.47,49.12 56.47,52.45 70.51,66.49 70.51,72.23 74.69,76.4 v1(75.42,76.4)
  BOTTOM w0.076: CPU1.V35 78.66,84.73 78.5,84.58 78.4,84.31 78.4,84.06 78.42,84 78.42,83.27 77.82,82.66 77.82,82.01 77.61,81.8 77.61,81.4
  BOTTOM w0.14: 77.61,81.4 77.61,79.23 77.57,77.22 76.76,76.4 v1(75.42,76.4) ; v1(57.59,45.64) 57.61,45.64 58.57,44.68 58.57,42.91 DM1.114
M_A_ALERT_N: length 50.1
  L5 w0.14: v1(59.08,44.35) 58.35,45.07 58.35,52.55 72.71,66.91 72.71,72.65 75.46,75.4 75.78,75.4 76.42,76.04 76.42,78.69 v1(78.05,80.33)
  BOTTOM w0.076: CPU1.W37 79.17,83.72 79.17,82.77 78.93,82.53 78.93,81.86 78.61,81.54 78.61,80.89 v1(78.05,80.33)
  BOTTOM w0.14: v1(59.08,44.35) DM1.116
M_A_BA0: length 52.4
  L5 w0.14: v1(69.03,45.03) 68.3,45.75 68.44,47.69 68.44,49.22 82.5,63.28 82.5,75.29 81.88,75.91 81.88,79.59 82.34,80.06 82.34,82.14 79.23,85.26 v1(78.97,86.54)
  BOTTOM w0.14: CPU1.W32 v1(78.97,86.54) ; DM1.150 69.58,44.73 69.27,45.03 v1(69.03,45.03)
M_A_BA1: length 55.8
  L5 w0.14: v1(80.75,87.89) 79.94,87.08 79.94,86.11 80.34,85.7 80.34,84.97 81.65,83.66 82.59,83.66 82.84,83.41 82.84,83.06 82.83,83.04 82.83,79.84 82.97,79.69 82.97,78.35 83.01,78.32 83.01,78.04 83.42,77.63 83.42,63.01 70.89,50.49 70.89,48.59 70.49,48.19 70.49,46.89 70.18,46.58 69.6,46.58 69.48,46.71 69.48,46.71 v1(69.29,46.89)
  BOTTOM w0.14: CPU1.AB31 v1(80.75,87.89) ; DM1.145 68.33,47.1 68.53,46.89 v1(69.29,46.89)
M_A_BG0: length 54.6
  L5 w0.14: v1(78.04,81.6) 75.86,79.42 75.86,76.25 75.57,75.96 74.84,75.96 70.95,72.07 70.95,67.66 71.08,67.52 71.53,67.52 71.7,67.36 71.7,67.09 71.57,66.96 71.08,66.96 70.95,66.82 70.95,66.33 56.92,52.31 56.92,51.89 57.06,51.75 57.37,51.75 57.51,51.61 57.51,51.33 57.37,51.19 57.06,51.19 56.92,51.06 56.92,49.26 56.99,49.2 56.99,47.68 57.11,47.55 57.67,47.55 v1(57.85,47.73)
  BOTTOM w0.076: v1(78.04,81.6) 78.04,81.6 78.2,81.6 78.6,82 78.6,82.67 78.84,82.91 78.84,83.88 78.91,84.06 78.91,84.3 78.88,84.37 78.87,84.39 78.87,84.61 78.91,84.71 78.91,85.23 CPU1.V34
  BOTTOM w0.14: DM1.115 58.83,48.31 58.25,47.73 v1(57.85,47.73)
M_A_BG1: length 54.4
  L5 w0.14: v1(78.05,80.97) 76.14,79.05 76.14,76.1 75.72,75.68 75.15,75.68 72.29,72.82 72.29,72.12 72.15,71.98 71.5,71.98 71.36,71.84 71.36,71.57 71.5,71.43 72.15,71.43 72.29,71.29 72.29,71.01 72.15,70.87 71.5,70.87 71.36,70.73 71.36,70.45 71.5,70.31 72.15,70.31 72.29,70.17 72.29,69.89 72.15,69.75 71.5,69.75 71.36,69.61 71.36,69.33 71.5,69.19 72.15,69.19 72.29,69.05 72.29,68.77 72.15,68.63 71.5,68.63 71.36,68.49 71.36,68.21 71.5,68.07 72.15,68.07 72.29,67.93 72.29,67.09 57.93,52.72 57.93,50.38 57.37,49.83 57.37,49.45 57.64,49.19 57.65,49.19 v1(57.83,49)
  BOTTOM w0.076: CPU1.W35 79.08,84.93 79.08,84.71 79.05,84.62 79.05,84.39 79.07,84.33 79.07,84.03 79.01,83.85 79.01,82.84 78.77,82.6 78.77,81.93 78.45,81.61 78.45,81.36 v1(78.05,80.97)
  BOTTOM w0.14: v1(57.83,49) 58.2,49 58.33,49.13 DM1.113
M_A_CKE0: length 56.6
  L5 w0.14: v1(75.37,77.05) 74.69,77.05 70.09,72.46 70.09,66.67 55.3,51.87 55.3,51.45 55.44,51.31 55.91,51.31 56.05,51.17 56.05,50.89 55.91,50.75 55.44,50.75 55.3,50.62 55.3,50.34 55.44,50.2 55.91,50.2 56.05,50.06 56.05,49.78 55.91,49.64 55.44,49.64 55.3,49.5 55.3,49.33 54.92,48.95 54.92,47.63 55.12,47.42 55.55,47.42 55.9,47.77 v1(56.11,47.77)
  BOTTOM w0.076: CPU1.U36 78.1,84.41 78.24,84.03 78.26,83.97 78.26,83.33 77.63,82.7 77.63,82.11 77.27,81.75 77.27,81.36
  BOTTOM w0.14: v1(56.11,47.77) 56.48,47.4 57.08,47.4 57.33,47.65 DM1.109 ; 77.27,81.36 77.27,77.7 76.41,76.84 75.58,76.84 v1(75.37,77.05)
M_A_CKE1: length 56.6
  L5 w0.14: v1(75.29,78.32) 69.68,72.7 69.68,66.84 54.35,51.52 54.35,46.36 54.69,46.03 54.89,46.03 55.48,46.62 55.68,46.62 55.88,46.43 55.88,46.23 55.28,45.63 55.28,45.43 55.48,45.24 55.68,45.24 55.99,45.55 56.19,45.55 56.39,45.36 56.39,45.16 56.07,44.84 56.07,44.64 56.37,44.35 v1(57.58,44.35)
  BOTTOM w0.076: 76.98,81.46 76.98,81.72 77.43,82.18 77.43,82.74 78.01,83.32 78.01,83.85 CPU1.U37
  BOTTOM w0.14: DM1.110 v1(57.58,44.35) ; 76.98,81.46 76.98,78.71 76.59,78.32 v1(75.29,78.32)
M_A_CLK0: length 55.4
  L5 w0.102: v1(78.07,87.81) 78.41,87.29 78.44,87.25 78.44,85.73 79.4,84.77 79.4,84.46 79.2,84.26 79.2,84.11 79.33,83.99 79.47,83.99 79.67,84.19 79.99,84.19 80.77,83.4 80.77,83.16 81.03,82.89 81.28,82.89 82.12,82.05 82.12,80.15 81.66,79.68 81.66,75.17 81.89,74.94 81.89,63.27 68.01,49.39 68.01,47.86 67.77,47.62 67.26,47.62 v1(67.03,47.39)
  BOTTOM w0.114: v1(67.03,47.39) 66.8,47.61 66.34,47.61 64.78,49.17 64.78,49.43 64.46,49.75 64.46,50.12 64.33,50.26 DM1.137 ; CPU1.V31 78.12,87.77 v1(78.07,87.81)
M_A_CLK1: length 54.2
  L5 w0.102: v1(65.51,45.64) 65.76,45.89 65.76,49.79 65.76,50.12 80.19,64.54 80.19,74.07 80.55,74.44 80.55,77.39 80.55,79.9 79.32,81.14 79.32,82.37 76.35,85.33 76.35,86.65 76.63,86.93 76.63,87.26 v1(77.13,87.75)
  BOTTOM w0.114: v1(65.51,45.64) 65.51,45.64 64.82,45.35 64.58,45.1 DM1.138 ; CPU1.T31 v1(77.13,87.75)
M_A_CLK#0: length 55.5
  L5 w0.102: v1(67.03,48.28) 66.82,48.07 66.82,47.92 66.92,47.82 67.68,47.82 67.81,47.95 67.81,49.48 81.69,63.36 81.69,74.86 81.46,75.09 81.46,79.77 81.92,80.23 81.92,81.97 81.19,82.69 80.95,82.69 80.57,83.07 80.57,83.32 79.9,83.98 79.76,83.98 79.56,83.78 79.25,83.78 79,84.03 79,84.34 79.2,84.54 79.2,84.68 78.24,85.65 78.24,87.05 78.23,87.05 78.11,87.18 v1(77.96,87.18)
  BOTTOM w0.102: v1(77.96,87.18) 77.96,86.86 78.13,86.68 78.31,86.68 CPU1.V32
  BOTTOM w0.114: DM1.139 64.83,50.27 64.69,50.13 64.69,49.85 65.01,49.53 65.01,49.26 66.43,47.84 66.9,47.84 67.03,47.96 v1(67.03,48.28)
M_A_CLK#1: length 54.2
  L5 w0.102: v1(65.38,44.96) 65.62,44.96 65.97,45.31 65.97,49.71 65.97,49.71 65.97,50.03 80.39,64.45 80.39,73.99 80.75,74.35 80.75,79.98 79.52,81.22 79.52,82.45 76.55,85.42 76.55,86.56 v1(77.1,87.11)
  BOTTOM w0.114: v1(65.38,44.96) 65.19,45.16 64.95,45.16 64.8,45.01 64.8,44.18 65.08,43.91 DM1.140 ; v1(77.1,87.11) 77.15,86.89 77.33,86.79 CPU1.T32
M_A_CS#0: length 59.2
  L5 w0.14: v1(72.52,46.02) 72.7,46.2 72.7,46.27 72.97,46.53 73.46,46.53 74.32,47.39 74.32,49.89 75.06,50.62 76.95,50.62 84.45,58.13 84.45,58.32 83.97,58.8 83.97,59 84.17,59.2 84.37,59.2 84.85,58.72 85.04,58.72 85.24,58.92 85.24,59.11 84.76,59.59 84.76,59.79 84.96,59.99 85.16,59.99 85.64,59.51 85.83,59.51 86.13,59.81 86.13,77.86 85.86,78.13 85.86,83.63 85.31,84.18 84.38,84.18 83.49,85.07 v1(83.49,86.62)
  BOTTOM w0.14: v1(83.49,86.62) 83.49,86.64 83.06,86.86 CPU1.AE32 ; DM1.149 69.33,49.8 69.8,49 v1(72.52,46.02)
M_A_CS#1: length 60.1
  L5 w0.14: v1(84.38,86.57) 84.38,86.12 84.31,86.05 84.31,85.26 84.76,84.81 85.36,84.81 86.53,83.64 86.53,83.26 87.08,82.71 87.08,58.35 84.83,56.1 84.63,56.1 84.31,56.42 84.11,56.42 83.91,56.23 83.91,56.03 84.24,55.71 84.24,55.51 84.04,55.31 83.84,55.31 83.52,55.63 83.32,55.63 83.12,55.44 83.12,55.24 83.45,54.92 83.45,54.72 83.25,54.52 83.05,54.52 82.73,54.84 82.53,54.84 82.33,54.65 82.33,54.45 82.66,54.13 82.66,53.93 82.46,53.73 82.26,53.73 81.94,54.05 81.74,54.05 81.54,53.86 81.54,53.66 81.87,53.33 81.87,53.14 77.52,48.79 77.36,48.79 76.66,48.09 76.66,46.18 76.31,45.83 v1(74.48,45.83)
  BOTTOM w0.14: CPU1.AF32 v1(84.38,86.57) ; DM1.157 71.33,50.17 72.36,48.6 73.7,47.26 v1(74.48,45.83)
M_A_DIMA_ODT0: length 59.3
  L5 w0.14: v1(73.24,47.01) 73.36,47.01 73.79,47.45 73.79,50.29 74.54,51.04 76.77,51.04 80.19,54.46 80.39,54.66 80.39,54.86 79.91,55.34 79.91,55.53 80.11,55.73 80.31,55.73 80.79,55.25 80.98,55.25 81.18,55.45 81.18,55.65 80.7,56.13 80.7,56.33 80.9,56.52 81.1,56.52 81.58,56.04 81.78,56.04 81.97,56.24 81.97,56.44 81.49,56.92 81.49,57.12 81.69,57.31 81.89,57.31 82.37,56.83 82.57,56.83 82.76,57.03 82.76,57.23 82.28,57.71 82.28,57.91 85.59,61.22 85.59,76.9 85.61,76.92 85.61,83.53 85.22,83.92 85.02,83.92 84.25,83.92 83.07,85.11 83.07,86.84 v1(83.49,87.27)
  BOTTOM w0.14: DM1.155 70.83,49.43 v1(73.24,47.01) ; CPU1.AE31 v1(83.49,87.27)
M_A_DIMA_ODT1: length 58.6
  L5 w0.14: v1(74.81,47.09) 74.86,47.14 74.94,47.14 75.29,47.49 75.29,47.86 75.29,47.87 75.29,48.87 76.62,50.2 77.12,50.2 77.34,50.42 77.53,50.42 77.94,50.01 78.13,50.01 78.33,50.21 78.33,50.41 77.93,50.81 77.93,51.01 78.13,51.21 78.32,51.21 78.73,50.8 78.92,50.8 79.12,51 79.12,51.2 78.72,51.6 78.72,51.8 78.92,52 79.11,52 79.52,51.6 79.71,51.6 79.91,51.79 79.91,51.99 79.51,52.39 79.51,52.59 79.71,52.79 79.9,52.79 80.31,52.39 80.51,52.39 80.7,52.58 80.7,52.78 80.3,53.18 80.3,53.38 86.55,59.63 86.55,77.94 86.84,78.23 86.84,82.51 86.23,83.11 86.23,83.6 85.4,84.43 84.53,84.43 83.95,85.01 83.95,86.8 v1(84.37,87.22)
  BOTTOM w0.14: DM1.161 72.33,49.22 74.45,47.09 v1(74.81,47.09) ; CPU1.AF31 v1(84.37,87.22)
M_A_DQ0: length 67.8
  L5 w0.114: v1(63.05,91.11) 62.51,90.57 61.36,90.57 60.29,89.51 60.29,88.63 56.64,84.99 56.64,82.68 56.82,82.5 56.82,69.48 38.08,50.75 38.08,47.06 38.08,47.06 37.41,46.39 v1(36.11,46.39)
  BOTTOM w0.076: 64.47,90.74 64.8,90.74 64.92,90.61 66.2,90.61 66.89,91.05 66.91,91.05 68.39,91.05 CPU1.A26
  BOTTOM w0.114: v1(63.05,91.11) 63.44,90.71 64.06,90.71 64.08,90.74 64.47,90.74 ; DM1.28 37.08,45.61 36.29,46.39 v1(36.11,46.39)
M_A_DQ1: length 68.9
  L5 w0.114: v1(39.63,49.03) 40.07,49.46 40.07,50.79 58.75,69.47 58.75,73.39 58.9,73.54 58.9,73.77 58.78,73.88 58.32,73.88 58.2,74 58.2,74.34 58.34,74.47 59,74.47 59.13,74.6 59.13,74.83 59.01,74.94 58.32,74.94 58.2,75.06 58.2,75.29 58.32,75.4 59.01,75.4 59.13,75.51 59.13,75.74 59.01,75.86 58.32,75.86 58.2,75.97 58.2,76.2 58.32,76.31 59.01,76.31 59.13,76.43 59.13,76.66 59.01,76.77 58.32,76.77 58.2,76.89 58.2,77.11 58.32,77.23 59.01,77.23 59.13,77.34 59.13,77.57 59.01,77.69 58.32,77.69 58.2,77.8 58.2,78.03 58.32,78.14 59.01,78.14 59.13,78.26 59.13,79.14 62.45,82.46 62.45,88.48 v1(62.49,88.52)
  BOTTOM w0.076: CPU1.D26 70.88,90.05 70.67,89.84 70.43,89.84 69.86,89.84 69.73,89.89 69.43,89.89 69.36,89.87 69.14,89.87 68.98,89.92 67.96,89.92 67.74,90.15 66.76,90.15
  BOTTOM w0.089: 66.76,90.15 66.51,89.89 66.35,89.89 66.28,89.82 65.15,89.82 65.12,89.79 64.8,89.79 64.27,89.25 64.27,89.21
  BOTTOM w0.114: 64.27,89.21 63.58,88.52 v1(62.49,88.52) ; v1(39.63,49.03) 39.19,49.47 39.19,50.19 39.33,50.32 DM1.37
M_A_DQ2: length 68.6
  L5 w0.114: v1(40.6,44.45) 41.17,44.45 41.48,44.76 41.48,46.71 41.6,46.83 41.95,46.83 42.07,46.94 42.07,47.17 41.95,47.28 41.6,47.28 41.12,47.76 41.12,50.25 61.83,70.96 61.83,76.44 61.71,76.56 61.48,76.56 61.37,76.67 61.37,76.9 61.48,77.01 61.71,77.01 61.83,77.13 61.83,77.36 61.71,77.47 61.48,77.47 61.37,77.59 61.37,77.81 61.48,77.93 61.71,77.93 61.83,78.04 61.83,78.27 61.71,78.39 61.48,78.39 61.37,78.5 61.37,78.73 61.48,78.84 61.71,78.84 61.83,78.96 61.83,79.19 61.71,79.3 61.48,79.3 61.37,79.42 61.37,79.64 61.48,79.76 61.71,79.76 61.83,79.87 61.83,80.38 63.48,82.04 63.48,87.3 64.26,88.08 66.72,88.08 66.83,87.96 66.83,87.34 66.94,87.22 67.17,87.22 67.29,87.34 67.29,87.96 67.4,88.08 67.59,88.08 67.72,88.21 67.72,88.83 v1(67.53,89.02)
  BOTTOM w0.076: CPU1.D28 70.27,89.18 69.33,89.18 69.08,89.04 68.7,89.04 68.49,89.25 67.76,89.25 v1(67.53,89.02)
  BOTTOM w0.114: DM1.42 40.58,44.43 v1(40.6,44.45)
M_A_DQ3: length 68
  L5 w0.114: v1(36.07,44.43) 38.43,46.79 38.43,50.6 57.17,69.35 57.17,78.68 61.42,82.93 61.42,86.41 60.63,87.2 60.63,89.36 61.43,90.16 63.78,90.16 v1(64.76,89.18)
  BOTTOM w0.076: CPU1.C28 70.22,89.47 70.12,89.57 69.7,89.72 69.46,89.72 69.42,89.71 69.41,89.7 69.11,89.7 68.95,89.76 67.89,89.76 67.82,89.83 66.86,89.83
  BOTTOM w0.089: 66.86,89.83 66.7,89.83 66.58,89.71 66.42,89.71 66.36,89.65 65.22,89.65 v1(64.76,89.18)
  BOTTOM w0.114: v1(36.07,44.43) 36.08,44.43 DM1.24
M_A_DQ4: length 66.1
  L5 w0.114: v1(37.3,48.32) 37.74,48.76 37.74,50.89 56.48,69.63 56.48,82.36 56.3,82.54 56.3,85.13 59.13,87.96 59.13,88.12 58.96,88.29 58.96,88.45 59.12,88.61 59.28,88.61 59.45,88.44 59.61,88.44 59.77,88.6 59.77,88.77 59.5,89.04 59.5,89.2 61.21,90.91 62.19,90.91 62.87,91.59 64.09,91.59 v1(64.42,91.27)
  BOTTOM w0.076: v1(64.42,91.27) 64.59,91.09 64.69,91.09 65,90.78 66.08,90.78 66.73,91.19 66.89,91.22 68.42,91.22 69.06,91.01 CPU1.B26
  BOTTOM w0.114: DM1.25 36.33,48.95 36.95,48.32 v1(37.3,48.32)
M_A_DQ5: length 67.2
  L5 w0.114: v1(37.3,49.67) 37.4,49.76 37.4,51.03 56.14,69.77 56.14,82.22 55.96,82.39 55.96,85.27 56.85,86.16 56.85,86.32 56.67,86.5 56.67,86.66 56.83,86.83 56.99,86.83 57.17,86.65 57.33,86.65 57.49,86.81 57.49,86.97 57.31,87.15 57.31,87.31 57.48,87.47 57.64,87.47 57.82,87.29 57.98,87.29 58.14,87.46 58.14,87.62 57.96,87.8 57.96,87.96 59.16,89.15 59.16,89.34 61.07,91.26 62.05,91.26 62.73,91.93 63.95,91.93 64.12,92.1 66.77,92.1 66.89,91.97 66.89,91.3 66.81,91.22 v1(65.8,91.22)
  BOTTOM w0.076: v1(65.8,91.22) 66.88,91.38 68.45,91.38 69.25,91.13 69.74,91.09 CPU1.C26
  BOTTOM w0.114: DM1.29 37.33,49.69 v1(37.3,49.67)
M_A_DQ6: length 67.4
  L5 w0.114: v1(40.57,45.72) 40.75,45.53 41,45.53 41.12,45.66 41.12,46.74 40.78,47.08 40.78,50.47 61.03,70.73 61.03,71.82 61.14,71.94 61.37,71.94 61.48,72.05 61.48,72.28 61.37,72.4 61.14,72.4 61.03,72.51 61.03,72.74 61.14,72.85 61.37,72.85 61.48,72.97 61.48,73.2 61.37,73.31 61.14,73.31 61.03,73.42 61.03,73.65 61.14,73.77 61.37,73.77 61.48,73.88 61.48,74.11 61.37,74.22 61.14,74.22 61.03,74.34 61.03,74.57 61.14,74.68 61.37,74.68 61.48,74.8 61.48,75.02 61.37,75.14 61.14,75.14 61.03,75.25 61.03,75.48 61.14,75.6 61.37,75.6 61.48,75.71 61.48,75.94 61.37,76.05 61.14,76.05 61.03,76.17 61.03,80.07 63.13,82.18 63.13,87.44 64.12,88.42 66.74,88.42 66.87,88.55 66.87,88.93 v1(66.66,89.13)
  BOTTOM w0.076: 67.29,89.36 67.35,89.42 68.56,89.42 68.76,89.21 69.06,89.21 69.24,89.32 69.52,89.47 CPU1.B28
  BOTTOM w0.089: 67.29,89.36 66.89,89.36 v1(66.66,89.13)
  BOTTOM w0.114: v1(40.57,45.72) 40.36,45.72 40.02,46.06 39.7,46.06 39.58,45.94 DM1.38
M_A_DQ7: length 66.9
  L5 w0.114: v1(39.56,47.75) 39.56,47.43 39.99,46.99 40.29,46.99 40.42,47.12 40.42,50.6 60.68,70.87 60.68,75.98 60.57,76.1 60.45,76.1 60.34,76.21 60.34,76.44 60.45,76.56 60.57,76.56 60.68,76.67 60.68,76.9 60.57,77.01 60.45,77.01 60.34,77.13 60.34,77.36 60.45,77.47 60.57,77.47 60.68,77.58 60.68,77.81 60.57,77.93 60.45,77.93 60.34,78.04 60.34,78.27 60.45,78.38 60.57,78.38 60.68,78.5 60.68,79.18 60.57,79.3 60.27,79.3 60.16,79.41 60.16,79.62 60.3,79.75 60.57,79.75 60.68,79.87 60.68,80.21 62.79,82.32 62.79,87.58 63.17,87.96 63.17,88.12 63.02,88.28 63.02,88.44 63.18,88.6 63.34,88.6 63.5,88.45 63.66,88.45 63.97,88.77 65.9,88.77 66.03,88.89 v1(66.03,89.18)
  BOTTOM w0.076: CPU1.A28 68.8,89.59 67.82,89.59 67.78,89.63 67.07,89.63
  BOTTOM w0.089: v1(66.03,89.18) 66.32,89.47 66.43,89.47 66.5,89.53 66.65,89.53 66.66,89.54 66.97,89.54 67.07,89.63
  BOTTOM w0.114: v1(39.56,47.75) 39.56,46.99 39.78,46.76 40.2,46.76 40.33,46.89 DM1.41
M_A_DQ8: length 59.2
  L5 w0.114: v1(65.26,87.58) 64.16,86.48 64.16,81.67 62.64,80.14 62.64,70.62 46.49,54.47 46.49,54.31 46.8,54 46.8,53.84 46.63,53.67 46.47,53.67 46.16,53.98 46,53.98 45.84,53.82 45.84,53.66 46.15,53.35 46.15,53.19 45.99,53.03 45.83,53.03 45.59,53.26 45.43,53.26 45.27,53.1 45.27,52.94 45.5,52.7 45.5,52.54 42.83,49.87 42.83,48.69 42.6,48.46 v1(41.91,48.46)
  BOTTOM w0.076: 67.09,88.16 67.51,88.16 67.65,88.3 68.28,88.3 68.28,88.3 68.51,88.3 68.72,88.51 69.04,88.51 69.52,88.31 CPU1.B30
  BOTTOM w0.089: v1(65.26,87.58) 65.26,87.94 65.47,88.16 67.09,88.16
  BOTTOM w0.114: v1(41.91,48.46) 42.4,48.95 42.4,50.19 42.33,50.26 DM1.49
M_A_DQ9: length 60.3
  L5 w0.114: v1(42.09,44.98) 42.1,44.98 43.51,46.4 43.51,49.58 47.73,53.8 47.73,54.74 63.33,70.33 63.33,79.86 64.85,81.38 64.85,85.91 65.15,86.22 66.13,86.22 66.25,86.1 66.61,86.1 67.08,86.57 v1(67.08,86.63)
  BOTTOM w0.076: v1(67.08,86.63) 67.46,87.01 67.58,87.01 68.01,87.43 68.93,87.43 69.13,87.35 69.37,87.35 69.43,87.37 69.72,87.37 69.85,87.32 69.85,87.32 70.67,87.32 70.88,87.53 CPU1.D30
  BOTTOM w0.114: v1(42.09,44.98) 41.58,44.47 DM1.46
M_A_DQ10: length 59.2
  L5 w0.114: v1(44.58,45.65) 45.57,44.65 46.23,44.65 46.46,44.88 46.46,46.36 46.55,46.45 46.55,50.18 53.12,56.75 53.12,56.92 52.83,57.21 52.83,57.37 52.99,57.53 53.15,57.53 53.44,57.24 53.61,57.24 53.77,57.4 53.77,57.56 53.47,57.86 53.47,58.02 53.63,58.18 53.8,58.18 54.09,57.89 54.25,57.89 54.41,58.05 54.41,58.21 54.12,58.5 54.12,58.67 65.04,69.59 65.04,79.15 66.56,80.67 66.56,82.31 67.59,83.34 v1(67.59,84.15)
  BOTTOM w0.089: v1(67.59,84.15) 67.59,84.78 68.62,85.81 68.62,85.81 68.72,85.9 68.87,85.9 CPU1.B33
  BOTTOM w0.114: v1(44.58,45.65) 45.37,45.65 45.58,45.44 DM1.62
M_A_DQ11: length 58.1
  L5 w0.114: v1(67.16,85.17) 67.24,85.09 67.24,84.38 67.18,84.32 67.18,83.46 66.22,82.5 66.22,80.81 64.7,79.29 64.7,69.73 52.21,57.24 52.21,57.08 52.5,56.78 52.5,56.62 46.21,50.32 46.21,46.59 45.7,46.08 44.15,46.08 43.9,45.83 43.9,44.5 44.06,44.34 v1(44.58,44.34)
  BOTTOM w0.076: v1(67.16,85.17) 67.37,85.17 68.25,86.05 68.62,86.05 68.98,86.41 69.1,86.53 69.29,86.61 69.37,86.65 69.39,86.66 70.28,86.66 CPU1.D32
  BOTTOM w0.114: v1(44.58,44.34) DM1.58
M_A_DQ12: length 57.9
  L5 w0.114: v1(42.14,46.25) 43.17,47.29 43.17,49.73 47.39,53.94 47.39,54.88 62.98,70.48 62.98,80 64.51,81.52 64.51,86.06 65.07,86.62 65.16,86.62 v1(66.12,87.58)
  BOTTOM w0.076: 67.24,87.91 67.49,87.91 67.72,88.14 68.35,88.14 68.35,88.14 68.58,88.14 68.7,88.25 CPU1.A30
  BOTTOM w0.089: v1(66.12,87.58) 66.45,87.91 67.24,87.91
  BOTTOM w0.114: v1(42.14,46.25) 42.58,45.82 DM1.50
M_A_DQ13: length 58.9
  L5 w0.114: v1(64.08,87.28) 63.82,87.02 63.82,81.81 62.3,80.28 62.3,70.76 44.41,52.87 44.41,52.71 44.71,52.4 44.71,52.24 44.55,52.08 44.39,52.08 44.08,52.39 43.92,52.39 43.76,52.22 43.76,52.06 44.07,51.75 44.07,51.59 43.91,51.43 43.74,51.43 43.44,51.74 43.27,51.74 43.11,51.58 43.11,51.42 43.42,51.11 43.42,50.95 43.26,50.78 43.1,50.78 42.79,51.09 42.63,51.09 41.56,50.02 v1(41.56,49.63)
  BOTTOM w0.076: CPU1.C30 70.08,88.25 69.73,88.61 69.23,88.61 69.08,88.67 68.65,88.67 68.45,88.47 68.21,88.47 67.44,88.47 67.32,88.34
  BOTTOM w0.089: 67.32,88.34 64.71,88.34 64.08,87.71 v1(64.08,87.28)
  BOTTOM w0.114: v1(41.56,49.63) 41.34,49.86 41.34,50.28 41.33,50.29 DM1.45
M_A_DQ14: length 57.3
  L5 w0.114: v1(44.25,47.04) 44.25,46.69 44.51,46.43 45.55,46.43 45.86,46.75 45.86,50.47 51.84,56.45 51.84,57.36 64.35,69.87 64.35,79.43 65.88,80.95 65.88,82.77 66.37,83.26 66.37,83.29 66.37,83.29 66.37,85.05 v1(66.53,85.21)
  BOTTOM w0.076: CPU1.B32 69.56,86.96 69.29,86.8 69,86.67 68.82,86.48 68.55,86.22 67.91,86.22
  BOTTOM w0.089: v1(66.53,85.21) 67.54,86.22 67.91,86.22
  BOTTOM w0.114: DM1.59 44.83,47.44 44.42,47.04 v1(44.25,47.04)
M_A_DQ15: length 57.9
  L5 w0.114: v1(46.99,47.52) 47.55,47.52 47.7,47.68 47.7,50.85 55.12,58.27 55.12,58.43 54.82,58.72 54.82,58.88 54.98,59.05 55.15,59.05 55.44,58.75 55.6,58.75 55.76,58.91 55.76,59.07 55.47,59.37 55.47,59.53 55.63,59.69 55.79,59.69 56.09,59.4 56.25,59.4 56.49,59.64 56.49,59.82 56.21,60.1 56.21,60.28 65.38,69.44 65.38,79 66.88,80.5 66.88,82.12 68.56,83.8 68.56,85.8 v1(67.74,86.62)
  BOTTOM w0.076: CPU1.C32 69.98,86.95 69.74,87.19 69.69,87.21 69.46,87.21 69.41,87.19 69.4,87.18 69.08,87.18 69.07,87.2 68.9,87.27 68.4,87.27 v1(67.74,86.62)
  BOTTOM w0.114: DM1.63 45.83,50.17 45.93,50.06 45.93,48.59 v1(46.99,47.52)
M_A_DQ16: length 64
  L5 w0.114: v1(73.31,92.61) 71.66,92.61 69.62,90.58 69.62,82.39 67.77,80.54 67.77,78.08 66.9,77.21 66.9,68.75 64.44,66.29 64.44,66.13 64.69,65.88 64.69,65.72 64.53,65.55 64.37,65.55 64.12,65.81 63.95,65.81 63.79,65.65 63.79,65.48 64.05,65.23 64.05,65.07 49.96,50.99 49.96,47.7 47.87,45.61 v1(46.95,45.61)
  BOTTOM w0.114: CPU1.J22 73.48,92.78 v1(73.31,92.61) ; v1(46.95,45.61) 46.53,45.19 46.53,44.15 46.58,44.11 DM1.66
M_A_DQ17: length 66.6
  L5 w0.114: v1(73.18,90.63) 73,90.45 73,86.81 73.41,86.4 73.41,85.52 73.78,85.16 73.78,84.47 73.89,84.35 74.06,84.35 74.17,84.24 74.17,84.01 74.06,83.9 73.89,83.9 73.78,83.78 73.78,83.55 73.89,83.44 74.06,83.44 74.17,83.32 74.17,83.1 74.06,82.98 73.89,82.98 73.78,82.87 73.78,82.64 73.89,82.52 74.06,82.52 74.17,82.41 74.17,82.18 74.06,82.07 73.89,82.07 73.65,81.82 73.65,81.66 73.82,81.49 73.82,81.33 73.65,81.17 73.49,81.17 73.32,81.34 73.16,81.34 73,81.18 73,81.02 73.17,80.85 73.17,80.69 73.01,80.52 72.85,80.52 72.68,80.69 72.52,80.69 72.35,80.53 72.35,80.37 72.52,80.2 72.52,80.04 72.36,79.88 72.2,79.88 72.03,80.05 71.87,80.05 71.15,79.33 71.15,75.59 68.69,73.13 68.69,67.26 53.33,51.91 53.33,46.31 53.22,46.19 52.37,46.19 52.25,46.08 52.25,45.85 52.37,45.73 53.22,45.73 53.33,45.62 53.33,45.28 53.01,44.96 52.1,44.96 v1(51.17,45.89)
  BOTTOM w0.114: v1(51.17,45.89) 50.87,45.89 50.08,45.1 DM1.80 ; v1(73.18,90.63) 73.07,90.95 CPU1.H25
M_A_DQ18: length 63.3
  L5 w0.114: v1(48.31,47.6) 49.28,48.57 49.28,51.27 61.41,63.4 61.41,63.56 61.23,63.74 61.23,63.9 61.4,64.06 61.56,64.06 61.73,63.89 61.89,63.89 62.06,64.05 62.06,64.21 61.77,64.5 61.77,64.66 61.93,64.82 62.09,64.82 62.38,64.53 62.54,64.53 62.7,64.7 62.7,64.86 62.42,65.14 62.42,65.3 66.2,69.08 66.2,78.82 67.34,79.96 67.34,81.48 69.05,83.2 69.05,90.87 71.34,93.16 72.07,93.16 v1(72.48,93.57)
  BOTTOM w0.114: CPU1.G22 v1(72.48,93.57) ; v1(48.31,47.6) 47.29,48.62 47.06,48.62 46.57,49.11 46.57,49.95 46.83,50.2 DM1.67
M_A_DQ19: length 63.2
  L5 w0.114: v1(73.15,93.6) 72.42,92.88 71.52,92.88 69.31,90.67 69.31,82.97 67.55,80.72 67.55,79.65 66.54,77.63 66.54,68.94 63.38,65.78 63.38,64.88 49.62,51.13 49.62,48.29 48.52,47.19 v1(46.99,46.88)
  BOTTOM w0.114: DM1.70 47.58,46.3 v1(46.99,46.88) ; CPU1.H22 v1(73.15,93.6)
M_A_DQ20: length 67
  L5 w0.114: v1(51.19,48.43) 52.47,48.43 52.64,48.6 52.64,49.28 52.53,49.4 51.68,49.4 51.57,49.51 51.57,49.74 51.68,49.85 52.53,49.85 52.64,49.97 52.64,50.2 52.53,50.31 51.68,50.31 51.57,50.42 51.57,50.65 51.68,50.77 52.53,50.77 52.64,50.88 52.64,51.11 52.53,51.22 52.24,51.22 52.12,51.34 52.12,51.57 52.24,51.68 52.53,51.68 52.64,51.8 52.64,52.19 68,67.55 68,75.21 69.22,76.43 69.22,79.53 70.79,81.1 71.71,81.1 71.85,81.25 71.85,81.59 71.74,81.71 71.11,81.71 71,81.82 71,82.05 71.11,82.16 71.84,82.16 71.95,82.28 71.95,82.51 71.84,82.62 71.11,82.62 71,82.74 71,82.96 71.11,83.08 71.84,83.08 71.95,83.19 71.95,83.42 71.84,83.54 71.11,83.54 71,83.65 71,83.88 71.11,83.99 71.84,83.99 71.95,84.11 71.95,84.34 71.84,84.45 71.11,84.45 71,84.56 71,84.79 71.11,84.91 71.74,84.91 71.85,85.02 71.85,85.78 71.18,86.45 71.18,90.27 v1(71.48,90.57)
  BOTTOM w0.114: DM1.83 50.83,49.95 50.67,49.8 50.67,48.66 50.9,48.43 v1(51.19,48.43) ; CPU1.F25 71.53,90.66 71.49,90.62 71.49,90.57 v1(71.48,90.57)
M_A_DQ21: length 65.2
  L5 w0.114: v1(51.17,44.57) 51.17,44.32 51.3,44.2 52.94,44.2 53.67,44.93 53.67,51.77 69.03,67.12 69.03,72.81 72.72,76.5 72.72,79.6 74.77,81.65 75.28,81.65 75.42,81.79 75.42,81.99 75.3,82.11 74.77,82.11 74.65,82.22 74.65,82.45 74.77,82.56 75.28,82.56 75.42,82.7 75.42,82.91 75.3,83.02 74.77,83.02 74.65,83.14 74.65,83.36 74.77,83.48 75.28,83.48 75.42,83.62 75.42,83.82 75.3,83.94 74.77,83.94 74.65,84.05 74.65,84.28 74.77,84.39 75.28,84.39 75.42,84.53 75.42,84.74 75.3,84.85 74.77,84.85 73.71,85.9 73.71,87.2 73.88,87.37 73.88,90.56 v1(73.82,90.63)
  BOTTOM w0.114: v1(73.82,90.63) 73.82,90.74 CPU1.J25 ; v1(51.17,44.57) 51.08,44.47 DM1.84
M_A_DQ22: length 63.8
  L5 w0.114: v1(72.44,90.65) 72.08,90.28 72.08,86.56 72.88,85.76 72.88,85.1 72.99,84.99 73.24,84.99 73.36,84.88 73.36,84.65 73.24,84.53 72.99,84.53 72.88,84.42 72.88,84.19 72.99,84.08 73.24,84.08 73.36,83.96 73.36,83.73 73.24,83.62 72.99,83.62 72.88,83.5 72.88,82.32 72.99,82.21 73.17,82.21 73.28,82.09 73.28,81.87 73.17,81.75 72.99,81.75 70.71,79.47 70.71,75.79 68.34,73.42 68.34,67.41 52.99,52.05 52.99,47.99 52.87,47.88 51.83,47.88 51.72,47.77 51.72,47.54 51.83,47.42 52.87,47.42 52.99,47.31 52.99,46.97 52.86,46.84 51.5,46.84 v1(51.19,47.16)
  BOTTOM w0.114: v1(51.19,47.16) 50.89,47.16 49.82,48.23 49.82,51.09 DM1.79 ; CPU1.G25 72.18,90.92 72.43,90.67 72.43,90.66 v1(72.44,90.65)
M_A_DQ23: length 63
  L5 w0.114: v1(71.83,93.6) 71.33,93.6 68.84,91.1 68.84,83.54 67.12,81.83 67.12,80.26 65.85,78.99 65.85,69.23 60.45,63.83 60.45,63.67 60.74,63.38 60.74,63.22 60.58,63.06 60.42,63.06 60.13,63.34 59.97,63.34 59.81,63.18 59.81,63.02 60.09,62.73 60.09,62.57 59.93,62.41 59.77,62.41 59.48,62.7 59.32,62.7 59.16,62.54 59.16,62.37 59.45,62.09 59.45,61.93 59.29,61.76 59.12,61.76 58.84,62.05 58.68,62.05 58.51,61.89 58.51,61.73 58.8,61.44 58.8,61.28 58.64,61.12 58.48,61.12 58.19,61.4 58.03,61.4 57.87,61.24 57.87,61.08 58.15,60.79 58.15,60.63 57.99,60.47 57.83,60.47 57.54,60.76 57.38,60.76 57.22,60.6 57.22,60.43 57.51,60.15 57.51,59.99 57.37,59.85 57.37,59.85 48.94,51.41 48.94,51.04 48.92,51.03 48.92,49.58 v1(48.24,48.9)
  BOTTOM w0.114: v1(48.24,48.9) 47.83,49.31 DM1.71 ; v1(71.83,93.6) 71.53,93.29 CPU1.F22
M_A_DQ24: length 74.8
  L5 w0.114: v1(31.83,49.44) 31.55,49.44 31.42,49.56 31.42,50.14 52.48,71.2 52.48,87.52 61.2,96.24 61.55,96.24 61.66,96.13 61.66,95.9 61.78,95.78 62,95.78 62.12,95.9 62.12,96.13 62.23,96.24 62.46,96.24 62.58,96.13 62.58,95.9 62.69,95.78 62.92,95.78 63.03,95.9 63.03,96.13 63.15,96.24 63.38,96.24 63.49,96.13 63.49,95.9 63.6,95.78 63.83,95.78 63.95,95.9 63.95,96.13 64.06,96.24 64.29,96.24 64.4,96.13 64.4,95.9 64.52,95.78 64.75,95.78 64.86,95.9 64.86,96.13 64.98,96.24 66.42,96.24 67.81,94.86 v1(67.81,94.26)
  BOTTOM w0.076: 68.1,93.97 68.4,93.86 69.06,93.7 69.25,93.64 70.34,93.54 70.71,93.37 CPU1.D22
  BOTTOM w0.089: 68.1,93.97 v1(67.81,94.26)
  BOTTOM w0.114: DM1.7 v1(31.83,49.44)
M_A_DQ25: length 74.6
  L5 w0.114: v1(32.55,45.11) 32.95,45.51 32.95,45.64 32.95,45.64 32.95,46 32.95,46.01 32.95,46.24 32.98,46.28 32.98,46.64 32.95,46.67 32.95,48.35 32.95,48.35 32.95,48.86 32.95,48.86 32.95,50.21 53.51,70.77 53.51,87.09 61.16,94.74 64.65,94.74 v1(65.16,94.23)
  BOTTOM w0.076: 67.48,93.5 68.84,93.03 68.99,93.03 69.17,93.06 69.33,93.06 69.51,93.03 69.68,93.03 CPU1.C22
  BOTTOM w0.089: 66.02,93.8 66.53,93.8 66.98,93.52 67.48,93.5
  BOTTOM w0.114: v1(65.16,94.23) 64.96,94.04 64.96,93.83 65.09,93.7 65.92,93.7 66.02,93.8 ; DM1.8 32.08,45.11 32.22,45.26 32.4,45.26 v1(32.55,45.11)
M_A_DQ26: length 74.9
  L5 w0.114: v1(35.33,48.16) 35.67,47.83 35.85,47.83 36.15,48.13 36.15,51.47 54.88,70.2 54.88,86.52 60.64,92.29 61.26,92.29 v1(62.03,93.06)
  BOTTOM w0.076: 65.98,91.68 66,91.66 66.02,91.66 66.07,91.64 66.14,91.61 67.66,91.61 68.64,91.57 69.06,91.57 69.08,91.57 69.23,91.62 69.71,91.75 CPU1.C24
  BOTTOM w0.089: 65.98,91.68 65.33,91.68
  BOTTOM w0.114: v1(62.03,93.06) 62.02,93.06 61.58,92.61 60.96,92.61 60.84,92.48 60.84,91.82 60.96,91.69 61.56,91.69 61.68,91.58 61.68,90.82 61.79,90.7 62.02,90.7 62.13,90.82 62.13,91.57 62.27,91.71 65.24,91.71 65.26,91.68 65.33,91.68 ; DM1.17 34.33,50.01 34.48,49.86 34.48,49.11 34.55,49.04 34.55,47.8 34.67,47.68 34.94,47.68 35.33,48.07 v1(35.33,48.16)
M_A_DQ27: length 75.9
  L5 w0.114: v1(35.32,49.46) 34.88,49.02 34.57,49.02 34.47,49.12 34.47,50.28 34.78,50.59 34.94,50.59 35.32,50.21 35.48,50.21 35.64,50.37 35.64,50.53 35.27,50.91 35.27,51.07 54.54,70.34 54.54,86.66 60.92,93.05 v1(61.4,93.05)
  BOTTOM w0.076: 66.86,93.33 67.44,93.33 67.47,93.33 67.53,93.31 67.56,93.28 68.81,92.87 69,92.87 69.19,92.89 69.31,92.89 69.5,92.87 69.71,92.87 69.72,92.87 70,92.92 70.67,92.92 70.88,92.71 CPU1.D24
  BOTTOM w0.114: v1(61.4,93.05) 61.08,93.36 61.08,94.13 61.27,94.31 61.62,94.31 61.74,94.2 61.74,93.64 61.85,93.52 62.08,93.52 62.2,93.64 62.2,94.2 62.31,94.31 62.54,94.31 62.65,94.2 62.65,93.64 62.77,93.52 63,93.52 63.11,93.64 63.11,94.2 63.22,94.31 63.45,94.31 63.57,94.2 63.57,93.64 63.68,93.52 63.91,93.52 64.02,93.64 64.02,94.2 64.14,94.31 64.48,94.31 64.6,94.2 64.6,93.75 65.02,93.33 66.86,93.33 ; v1(35.32,49.46) 35.33,49.46 DM1.21
M_A_DQ28: length 73.3
  L5 w0.114: v1(32.54,46.46) 32.61,47.93 32.61,48.21 32.61,50.35 53.17,70.91 53.17,87.23 61.03,95.1 65.49,95.1 66.04,94.67 66.3,94.41 66.3,94.39 v1(66.5,94.23)
  BOTTOM w0.076: CPU1.A22 67.51,93.67 67.04,93.69 v1(66.5,94.23)
  BOTTOM w0.114: DM1.4 31.08,45.37 32.16,46.46 v1(32.54,46.46)
M_A_DQ29: length 73.9
  L5 w0.114: v1(67.13,94.24) 67.13,94.97 66.67,95.44 65.91,95.44 65.79,95.56 65.79,95.78 65.68,95.9 65.45,95.9 65.34,95.78 65.34,95.56 65.22,95.44 60.89,95.44 52.82,87.37 52.82,71.06 32.26,50.5 32.26,49.14 32.26,48.24 32.14,48.11 v1(31.8,48.11)
  BOTTOM w0.076: 67.75,93.8 69.04,93.53 69.06,93.52 CPU1.B22
  BOTTOM w0.089: 67.75,93.8 67.66,93.89 67.48,93.89 v1(67.13,94.24)
  BOTTOM w0.114: v1(31.8,48.11) 31.17,48.11 30.83,48.45 DM1.3
M_A_DQ30: length 73.4
  L5 w0.114: v1(34.08,44.56) 34.4,44.23 35.51,44.23 35.63,44.36 35.63,44.83 35.52,44.94 35.07,44.94 34.95,45.06 34.95,45.28 35.07,45.4 35.52,45.4 35.63,45.51 35.63,46.54 35.93,46.83 36.67,46.83 36.88,47.04 36.88,47.23 37,47.35 37.49,47.35 37.62,47.48 37.62,47.7 37.49,47.83 37.01,47.83 36.83,48.01 36.83,51.18 55.57,69.92 55.57,86.24 60.93,91.6 61.91,91.6 62.58,92.28 63.81,92.28 63.97,92.44 64.44,92.44 64.57,92.57 v1(64.57,93.04)
  BOTTOM w0.076: CPU1.A24 66.49,91.99
  BOTTOM w0.089: 66.49,91.99 66.2,91.99 65.83,92.36 64.8,92.36 64.57,92.58 v1(64.57,93.04)
  BOTTOM w0.114: DM1.16 v1(34.08,44.56)
M_A_DQ31: length 75
  L5 w0.114: v1(34.04,45.96) 34.32,45.68 34.64,45.68 34.76,45.81 34.76,46.26 34.84,46.33 34.84,46.49 34.52,46.8 34.52,46.97 34.67,47.12 34.86,47.12 35.16,46.81 35.32,46.81 36.49,47.98 36.49,51.33 55.22,70.06 55.22,86.38 60.79,91.94 61.76,91.94 62.44,92.62 62.86,92.62 v1(63.3,93.06)
  BOTTOM w0.076: 66.15,91.8 66.24,91.8 67.27,91.8 68.88,91.73 69.03,91.73 CPU1.B24
  BOTTOM w0.089: 66.15,91.8 65.64,92.05
  BOTTOM w0.114: 65.64,92.05 64.24,92.05 64.12,92.17 64.12,92.48 64.01,92.6 63.78,92.6 63.66,92.48 63.66,92.17 63.55,92.05 63.15,92.05 62.97,92.23 62.97,92.74 v1(63.3,93.06) ; v1(34.04,45.96) 34.4,46.33 34.95,46.33 35.08,46.2 DM1.20
M_A_DQ32: length 53.9
  L3 w0.089: v1(84.87,48.14) 85.08,47.93 85.32,47.93 85.42,48.03 85.42,48.6 85.33,48.69 84.78,48.69 84.69,48.78 84.69,48.97 84.78,49.06 85.33,49.06 85.42,49.14 85.42,49.33 85.33,49.42 84.78,49.42 84.69,49.51 84.69,49.7 84.78,49.79 85.33,49.79 85.42,49.88 85.42,50.07 85.33,50.16 84.78,50.16 84.69,50.25 84.69,50.44 84.78,50.53 85.33,50.53 85.42,50.62 85.42,51.38 67.39,69.42 67.39,75.85 68.48,76.94 68.48,78.13 v1(68.21,78.41)
  BOTTOM w0.076: 71.8,82.54 72.02,82.75 72.52,83.28 72.89,83.78 CPU1.H37
  BOTTOM w0.089: 71.8,82.54 71.33,82.06 70.77,82.06
  BOTTOM w0.114: DM1.211 84.83,48.91 84.87,48.86 84.87,48.6 84.96,48.51 84.96,48.23 v1(84.87,48.14) ; v1(68.21,78.41) 69.19,79.39 69.19,80.9 70.35,82.06 70.77,82.06
M_A_DQ33: length 54.7
  L3 w0.089: v1(68.18,80.36) 66.98,79.17 66.98,77.32 66.59,76.93 66.59,69.08 83.47,52.21 83.47,47 84.01,46.46 84.01,44.27 84.13,44.15 84.85,44.15 v1(85.04,44.34)
  BOTTOM w0.076: CPU1.H34 72.83,85.52 72.69,85.23 72.69,84.28 72.62,84.15 72.59,84.1 72.34,83.85 72.34,83.64 72.06,83.36 71.99,83.36 71.24,82.62
  BOTTOM w0.114: v1(68.18,80.36) 68.18,80.7 70.09,82.61 71.23,82.61 71.24,82.62 ; DM1.212 85.08,44.3 v1(85.04,44.34)
M_A_DQ34: length 56.9
  L3 w0.089: v1(69.64,78.79) 70.13,78.79 70.26,78.67 70.26,75.79 70.17,75.7 69.88,75.7 69.79,75.61 69.79,75.42 69.88,75.33 70.17,75.33 70.26,75.24 70.26,75.05 70.17,74.96 69.88,74.96 69.79,74.88 69.79,74.69 69.88,74.6 70.17,74.6 70.26,74.51 70.26,74.32 70.17,74.23 69.88,74.23 69.79,74.14 69.79,73.95 69.88,73.86 70.17,73.86 70.26,73.77 70.26,73.5 70.17,73.42 69.88,73.42 69.79,73.33 69.79,73.14 69.88,73.05 70.17,73.05 70.26,72.96 70.26,72.77 70.17,72.68 69.88,72.68 69.79,72.59 69.79,72.4 69.88,72.31 70.17,72.31 70.26,72.22 70.26,72.03 70.17,71.94 69.88,71.94 69.79,71.85 69.79,71.66 69.88,71.57 70.17,71.57 70.26,71.48 70.26,69.01 89.57,49.71 v1(89.57,47.85)
  BOTTOM w0.076: CPU1.K34 73.55,85.81 73.34,85.6 73.34,84.78 73.35,84.76 73.39,84.65 73.39,84.35 73.39,84.35 73.37,84.3 73.37,84.06 73.39,84 73.39,83.54 72.96,83.11
  BOTTOM w0.089: 72.96,83.11 72.49,82.64
  BOTTOM w0.114: v1(69.64,78.79) 69.75,78.9 69.75,80.39 70.92,81.56 71.41,81.56 72.49,82.64 ; DM1.229 89.33,48.65 89.57,48.41 v1(89.57,47.85)
M_A_DQ35: length 55.9
  L3 w0.089: v1(88.59,44.98) 88.88,44.98 89,45.11 89,49.89 69.45,69.45 69.45,69.96 69.57,70.09 69.9,70.09 69.99,70.18 69.99,70.37 69.9,70.46 69.54,70.46 69.42,70.57 69.42,70.74 69.51,70.83 69.9,70.83 69.99,70.92 69.99,71.11 69.9,71.19 69.61,71.19 69.52,71.28 69.52,75.01 69.4,75.13 69.22,75.13 69.07,74.99 v1(69.07,74.99)
  BOTTOM w0.076: CPU1.K35 74.58,84.85 74.58,84.22 74.69,84.02 74.69,82.69 73.76,81.76
  BOTTOM w0.114: v1(88.59,44.98) 89.08,44.5 DM1.228 ; v1(69.07,74.99) 69.07,74.99 69.22,75.13 69.42,75.13 71.22,76.93 71.22,79.36 73.62,81.76 73.76,81.76
M_A_DQ36: length 54.8
  L3 w0.089: v1(68.21,79.04) 67.31,78.15 67.31,77.17 66.86,76.71 66.86,69.2 83.77,52.28 83.77,50.76 83.86,50.68 84.06,50.68 84.15,50.59 84.15,50.4 84.06,50.31 83.86,50.31 83.77,50.22 83.77,50.03 83.86,49.94 84.06,49.94 84.15,49.85 84.15,49.66 84.06,49.57 83.86,49.57 83.77,49.48 83.77,49.29 83.86,49.2 84.06,49.2 84.15,49.11 84.15,48.92 84.06,48.83 83.86,48.83 83.77,48.75 83.77,47.09 84.63,46.23 v1(84.97,46.23)
  BOTTOM w0.076: CPU1.H36 72.97,84.45 72.52,83.63 72.52,83.57 72.14,83.19 72.12,83.19 71.86,82.93
  BOTTOM w0.089: 70.89,82.29 71.23,82.29 71.86,82.93
  BOTTOM w0.114: DM1.216 86.08,43.82 85.91,43.99 85.91,45.48 85.15,46.23 v1(84.97,46.23) ; v1(68.21,79.04) 68.43,79.04 68.81,79.43 68.81,80.95 70.16,82.29 70.89,82.29
M_A_DQ37: length 55.8
  L3 w0.089: v1(84.98,46.87) 84.55,46.87 84.42,47 84.42,47.26 84.33,47.35 84.13,47.35 84.04,47.44 84.04,47.63 84.13,47.72 84.33,47.72 84.42,47.81 84.42,48 84.33,48.09 84.13,48.09 84.04,48.18 84.04,48.37 84.13,48.46 84.33,48.46 84.42,48.55 84.42,50.76 84.55,50.89 85.02,50.89 85.11,50.98 85.11,51.17 85.02,51.26 84.51,51.26 84.42,51.35 84.42,52.01 67.12,69.31 67.12,76.24 v1(68.02,77.14)
  BOTTOM w0.076: CPU1.H35 73.07,85.06 73.16,84.8 73.16,84.8 73.19,84.72 73.22,84.62 73.22,84.39 73.2,84.33 73.2,84.03 73.22,83.97 73.22,83.65 72.04,82.47
  BOTTOM w0.089: 70.63,81.81 71.38,81.81 72.04,82.47
  BOTTOM w0.114: DM1.215 85.83,50.1 85.71,49.99 85.71,47.61 v1(84.98,46.87) ; 70.63,81.81 69.45,80.64 69.45,79.3 69.12,78.97 69.12,78.23 v1(68.02,77.14)
M_A_DQ38: length 55.5
  L3 w0.089: v1(87.65,45.1) 88.11,45.1 88.6,45.59 88.6,45.86 88.51,45.95 88.26,45.95 88.17,46.04 88.17,46.22 88.26,46.31 88.51,46.31 88.6,46.39 88.6,49.92 69.12,69.4 69.12,73.51 69.03,73.6 68.7,73.6 68.61,73.69 68.61,73.88 68.7,73.97 69.17,73.97 69.26,74.05 69.26,74.23 69.16,74.33 68.75,74.33 68.66,74.42 68.66,75.62 69.21,76.18 v1(69.6,76.18)
  BOTTOM w0.076: CPU1.K36 74.27,84.45 74.4,84.21 74.4,84.2 74.53,83.97 74.53,82.8 73.71,81.98 73.55,81.98 73.33,81.76
  BOTTOM w0.114: DM1.224 88.08,44.68 v1(87.65,45.1) ; v1(69.6,76.18) 69.69,76.18 70.97,77.46 70.97,79.4 73.33,81.76
M_A_DQ39: length 54.7
  L3 w0.089: v1(69.64,77.5) 69.27,77.12 69.27,76.61 68.33,75.67 68.33,72.83 68.42,72.75 68.76,72.75 68.85,72.66 68.85,72.47 68.76,72.38 68.42,72.38 68.33,72.29 68.33,72.1 68.42,72.01 68.76,72.01 68.85,71.92 68.85,71.73 68.76,71.64 68.42,71.64 68.33,71.55 68.33,71.36 68.42,71.27 68.76,71.27 68.85,71.18 68.85,70.99 68.76,70.9 68.42,70.9 68.33,70.82 68.33,70.62 68.42,70.54 68.76,70.54 68.85,70.45 68.85,70.26 68.76,70.17 68.42,70.17 68.33,70.08 68.33,69.81 87.43,50.71 87.43,47.82 v1(87.94,47.31)
  BOTTOM w0.076: 73.36,82.14 73.64,82.14 74.27,82.78 CPU1.K37
  BOTTOM w0.114: v1(69.64,77.5) 70.74,78.59 70.74,79.53 73.36,82.14 ; v1(87.94,47.31) 88.44,47.8 88.44,48.67 88.33,48.78 DM1.225
M_A_DQ40: length 56.3
  L3 w0.089: v1(89.59,46.58) 89.92,46.58 90.05,46.71 90.05,46.82 90.13,46.91 90.33,46.91 90.41,47 90.41,47.19 90.33,47.28 90.13,47.28 90.05,47.37 90.05,47.56 90.13,47.65 90.33,47.65 90.41,47.73 90.41,47.92 90.33,48.01 90.13,48.01 90.05,48.1 90.05,48.29 90.13,48.38 90.33,48.38 90.41,48.47 90.41,48.66 90.33,48.75 90.13,48.75 90.05,48.84 90.05,49.88 70.73,69.19 70.73,77.21 70.82,77.3 71.11,77.3 71.2,77.39 71.2,77.58 71.11,77.67 70.82,77.67 70.73,77.75 70.73,77.95 70.82,78.03 70.98,78.03 71.07,78.12 71.07,78.31 70.98,78.4 70.82,78.4 70.73,78.49 70.73,78.76 70.86,78.89 71.36,78.89 v1(71.68,78.56)
  BOTTOM w0.076: CPU1.N36 75.49,84.48 75.33,84.2 75.33,84.17 75.16,83.84 75.16,82.66 73.77,81.27 73.76,81.27
  BOTTOM w0.114: DM1.236 91.08,44.02 91.09,44.04 91.09,45.08 v1(89.59,46.58) ; 73.76,81.27 72.09,79.6 72.09,78.97 v1(71.68,78.56)
M_A_DQ41: length 55.9
  L3 w0.089: v1(91.74,47.3) 91.44,47.3 91.32,47.42 91.32,48.46 91.4,48.55 91.85,48.55 91.94,48.64 91.94,48.83 91.85,48.92 91.4,48.92 91.32,49.01 91.32,49.74 71.53,69.53 71.53,74.65 71.62,74.74 72.05,74.74 72.14,74.83 72.14,75.02 72.05,75.11 71.62,75.11 71.53,75.2 71.53,75.46 71.66,75.59 71.86,75.59 72.08,75.81 72.08,78.2 72.44,78.56 72.44,79.07 72.32,79.2 v1(71.64,79.2)
  BOTTOM w0.076: CPU1.N34 75.17,85.15 75.17,84.21 74.99,83.89 74.99,82.73 73.72,81.46 73.64,81.46
  BOTTOM w0.114: v1(91.74,47.3) 91.33,47.71 DM1.237 ; 73.64,81.46 71.64,79.46 v1(71.64,79.2)
M_A_DQ42: length 55.3
  L3 w0.089: v1(75.11,80.21) 74.12,80.21 73.99,80.09 73.99,79.7 74.08,79.62 74.23,79.62 74.32,79.53 74.32,79.35 74.23,79.26 74.08,79.26 73.99,79.17 73.99,78.99 74.08,78.9 74.23,78.9 74.32,78.82 74.32,78.64 74.23,78.55 74.08,78.55 73.99,78.46 73.99,78.28 74.08,78.19 74.23,78.19 74.32,78.1 74.32,77.93 74.23,77.84 74.08,77.84 73.99,77.75 73.99,74.78 72.75,73.53 72.75,69.99 93.83,48.91 93.83,46.64 93.92,46.55 94.16,46.55 94.27,46.44 94.27,46.28 94.18,46.2 93.92,46.2 93.83,46.11 93.83,45.83 93.96,45.7 v1(94.62,45.7)
  BOTTOM w0.089: CPU1.R37 76.87,83.77 76.87,82.51 76.64,82.27
  BOTTOM w0.114: v1(75.11,80.21) 76.16,81.26 76.16,81.79 76.64,82.27 ; DM1.246 93.58,44.88 94.4,45.7 v1(94.62,45.7)
M_A_DQ43: length 55.4
  L3 w0.089: v1(73.54,79.78) 73.69,79.63 73.69,74.96 72.48,73.75 72.48,69.88 93.56,48.81 93.56,44.25 93.68,44.12 94.47,44.12 v1(94.68,44.34)
  BOTTOM w0.076: CPU1.R34 76.07,85.81 75.86,85.6 75.86,84.78 75.91,84.65 75.91,84.36 75.88,84.3 75.88,84.06 75.91,84 75.91,83.5 75.66,83.25 75.66,82.26
  BOTTOM w0.114: v1(94.68,44.34) 94.69,44.33 94.69,44.15 94.58,44.03 DM1.250 ; v1(73.54,79.78) 73.54,79.99 75.35,81.8 75.35,81.95 75.66,82.26
M_A_DQ44: length 55.1
  L3 w0.089: v1(71.66,77.29) 71.43,77.29 71,76.86 71,69.3 90.68,49.62 90.68,46.43 90.59,46.34 90.18,46.34 90.09,46.25 90.09,46.06 90.18,45.98 90.72,45.98 90.81,45.89 90.81,45.7 90.72,45.61 90.35,45.61 90.26,45.52 90.26,45.33 90.35,45.24 90.72,45.24 90.81,45.15 90.81,44.96 90.68,44.83 90.07,44.83 v1(89.59,45.31)
  BOTTOM w0.076: CPU1.N37 75.33,83.69 75.33,82.56 74.81,82.05
  BOTTOM w0.114: DM1.232 90.08,44.82 v1(89.59,45.31) ; v1(71.66,77.29) 72.39,78.03 72.39,79.62 74.81,82.04 74.81,82.05
M_A_DQ45: length 55.7
  L3 w0.089: v1(91.8,46) 91.47,46 90.96,46.51 90.96,49.72 71.26,69.41 71.26,73.54 71.25,73.56 71.25,76.25 v1(71.66,76.66)
  BOTTOM w0.076: 75.15,82.03 75.49,82.37 75.49,83.36 75.74,83.61 75.74,83.97 75.72,84.03 75.72,84.33 75.74,84.39 75.74,84.61 75.67,84.82 75.67,84.97 CPU1.N35
  BOTTOM w0.114: 75.15,82.03 72.77,79.66 72.77,77.49 71.94,76.66 71.66,76.65 v1(71.66,76.66) ; DM1.233 90.33,49.95 90.41,49.86 90.41,47.39 v1(91.8,46)
M_A_DQ46: length 56
  L3 w0.089: v1(75.17,79.58) 74.7,79.58 74.58,79.45 74.58,74.64 74.49,74.55 74.29,74.55 74.2,74.46 74.2,74.29 74.29,74.2 74.49,74.2 74.58,74.11 74.58,73.84 74.39,73.65 74.26,73.65 73.85,74.06 73.7,74.06 73.59,73.94 73.59,73.82 74.01,73.39 74.01,73.27 73.89,73.14 73.76,73.14 73.4,73.5 73.28,73.5 73.15,73.38 73.15,73.25 73.51,72.89 73.51,72.77 73.02,72.27 73.02,70.11 94.34,48.78 94.34,47.45 94.47,47.33 v1(94.88,47.33)
  BOTTOM w0.076: 76.75,82.06 77.04,82.35 77.04,83.99 76.79,84.45 CPU1.R36
  BOTTOM w0.114: DM1.245 93.33,48.85 94.79,47.38 94.82,47.38 v1(94.88,47.33) ; 76.75,82.06 76.41,81.71 76.41,80.82 v1(75.17,79.58)
M_A_DQ47: length 55.1
  L3 w0.089: v1(94.85,48.65) 73.28,70.22 73.28,72.16 74.52,73.4 75.4,73.4 75.49,73.49 75.49,73.65 75.38,73.76 74.95,73.76 74.86,73.85 74.86,74.03 74.95,74.11 75.5,74.11 75.59,74.2 75.59,74.38 75.5,74.47 74.95,74.47 74.86,74.56 74.86,74.74 74.95,74.83 75.5,74.83 75.59,74.92 75.59,75.09 75.5,75.18 74.95,75.18 74.86,75.27 74.86,75.45 74.95,75.54 75.5,75.54 75.59,75.63 75.59,75.8 75.5,75.89 74.95,75.89 74.86,75.98 74.86,78.59 v1(75.22,78.95)
  BOTTOM w0.076: 77.14,82.14 77.25,82.25 77.25,83.29 77.22,83.32 77.22,84 77.08,84.26 77.08,84.62 76.79,84.91 CPU1.R35
  BOTTOM w0.114: v1(75.22,78.95) 76.66,80.39 76.66,81.66 77.14,82.14 ; DM1.249 94.33,49.04 94.71,48.65 v1(94.85,48.65)
M_A_DQ48: length 61.8
  L3 w0.089: v1(72.53,87.21) 72.03,86.7 72.03,86.5 71.78,86.25 70.28,86.25 67.73,83.69 66.99,83.69 63.18,79.88 62.65,79.35 62.65,65.04 73.46,54.23 73.59,54.23 73.87,54.51 73.99,54.51 74.12,54.38 74.12,54.26 73.84,53.98 73.84,53.85 73.97,53.72 74.09,53.72 74.37,54 74.5,54 74.62,53.88 74.62,53.75 74.34,53.47 74.34,53.35 74.47,53.22 74.59,53.22 74.88,53.5 75,53.5 75.13,53.38 75.13,53.25 74.85,52.97 74.85,52.84 74.97,52.72 75.1,52.72 75.38,53 75.5,53 75.63,52.87 75.63,52.75 75.35,52.47 75.35,52.34 75.48,52.22 75.6,52.22 75.88,52.5 76.01,52.5 76.13,52.37 76.13,52.24 75.85,51.96 75.85,51.84 75.98,51.71 76.1,51.71 76.33,51.94 76.46,51.94 76.58,51.82 76.58,51.69 76.35,51.46 76.35,51.34 77.7,49.99 77.7,47.7 v1(77.28,47.28)
  BOTTOM w0.114: CPU1.G31 72.1,87.5 72.13,87.47 72.27,87.47 v1(72.53,87.21) ; v1(77.28,47.28) 77.73,47.73 77.73,48.13 77.71,48.15 77.71,49.78 77.83,49.89 DM1.183
M_A_DQ49: length 63.2
  L3 w0.089: v1(77.59,44.4) 77.48,44.4 76.86,45.02 76.86,47.16 76.56,47.46 76.56,47.63 76.55,47.64 76.55,50.71 67.4,59.86 67.27,59.86 67.03,59.62 66.9,59.62 66.78,59.75 66.78,59.87 67.02,60.11 67.02,60.24 66.89,60.37 66.77,60.37 66.52,60.12 66.4,60.12 66.27,60.25 66.27,60.37 66.52,60.62 66.52,60.74 66.39,60.87 66.26,60.87 66.02,60.63 65.9,60.63 65.77,60.75 65.77,60.88 66.01,61.12 66.01,61.25 65.89,61.37 65.76,61.37 65.52,61.13 65.39,61.13 65.27,61.25 65.27,61.38 65.51,61.62 65.51,61.75 65.38,61.87 65.26,61.87 65.02,61.63 64.89,61.63 64.76,61.76 64.76,61.88 65.01,62.13 65.01,62.25 64.88,62.38 64.76,62.38 64.51,62.13 64.39,62.13 64.26,62.26 64.26,62.39 64.5,62.63 64.5,62.75 64.38,62.88 64.25,62.88 64.01,62.64 63.88,62.64 63.76,62.76 63.76,62.89 64,63.13 64,63.26 63.88,63.38 63.75,63.38 63.51,63.14 63.38,63.14 63.26,63.27 63.26,63.39 63.5,63.63 63.5,63.76 63.37,63.89 63.25,63.89 63,63.64 62.88,63.64 62.75,63.77 62.75,63.89 63,64.14 63,64.26 62.38,64.88 62.38,79.51 68.25,85.37 68.79,85.37 70.08,86.66 v1(71.63,86.66)
  BOTTOM w0.114: v1(71.63,86.66) 71.81,86.85 CPU1.G32 ; v1(77.59,44.4) 77.58,44.38 DM1.182
M_A_DQ50: length 62.8
  L3 w0.089: v1(74.81,47.73) 74.28,47.73 73.96,48.05 73.96,50.6 73.66,50.9 73.66,51.02 74.01,51.37 74.01,51.5 73.88,51.63 73.76,51.63 73.41,51.28 73.28,51.28 73.15,51.4 73.15,51.53 73.5,51.88 73.5,52 73.38,52.13 73.25,52.13 72.9,51.78 72.78,51.78 61.19,63.37 61.19,80.72 63.5,83.03 63.5,87.31 64.33,88.13 70.64,88.13 71.51,89 72.38,89 v1(72.54,89.16)
  BOTTOM w0.114: v1(74.81,47.73) 74.79,47.73 74.33,48.2 DM1.169 ; v1(72.54,89.16) 72.65,89.16 CPU1.H29
M_A_DQ51: length 62.7
  L3 w0.089: v1(72.57,89.79) 71.78,89.2 71.16,89.2 71.08,89.28 70.18,89.28 68.28,88.4 64.44,88.4 64.22,88.4 63.24,87.42 63.24,83.22 60.92,80.91 60.92,63.26 73.69,50.49 73.69,47.94 74.23,47.4 74.23,46.7 74.97,45.96 v1(76.03,44.98)
  BOTTOM w0.114: CPU1.H28 72.67,89.79 v1(72.57,89.79) ; v1(76.03,44.98) 75.58,44.53 DM1.174
M_A_DQ52: length 61.5
  L3 w0.089: v1(74.58,44.56) 74.24,44.85 74.06,45.02 73.91,45.15 73.91,47.34 72.75,48.5 72.75,51.05 60.65,63.15 60.65,81.12 62.97,83.44 62.97,87.53 64.18,88.73 66.83,88.73 67.08,88.98 67.08,89.14 67.38,89.44 70.08,89.6 v1(71.6,89.6)
  BOTTOM w0.114: v1(71.6,89.6) 71.62,89.6 71.78,89.45 CPU1.G28 ; DM1.170 v1(74.58,44.56)
M_A_DQ53: length 63.1
  L3 w0.089: v1(71.64,88.56) 70.81,87.73 69.55,87.73 68.86,87.05 64.82,87.05 63.77,86 63.77,82.77 61.45,80.45 61.45,63.48 69.55,55.38 69.68,55.38 70.03,55.73 70.15,55.73 70.28,55.61 70.28,55.48 69.93,55.13 69.93,55.01 70.06,54.88 70.18,54.88 70.53,55.23 70.66,55.23 70.78,55.1 70.78,54.98 70.43,54.63 70.43,54.5 70.56,54.38 70.68,54.38 71.03,54.73 71.16,54.73 71.28,54.6 71.28,54.47 70.94,54.13 70.94,54 71.06,53.87 71.19,53.87 71.54,54.22 71.66,54.22 71.79,54.1 71.79,53.97 71.44,53.62 71.44,53.5 71.56,53.37 71.69,53.37 72.04,53.72 72.16,53.72 72.29,53.59 72.29,53.47 71.94,53.12 71.94,52.99 72.07,52.87 72.19,52.87 72.54,53.22 72.67,53.22 72.79,53.09 72.79,52.97 72.44,52.62 72.44,52.49 72.57,52.36 72.7,52.36 73.04,52.71 73.17,52.71 74.4,51.48 74.4,49.15 74.53,49.02 v1(74.83,49.02)
  BOTTOM w0.114: DM1.173 75.33,49.51 74.89,49.07 74.88,49.07 v1(74.83,49.02) ; v1(71.64,88.56) 71.64,88.57 71.87,88.57 CPU1.G29
M_A_DQ54: length 62.7
  L3 w0.089: v1(73.41,87.82) 72.93,87.34 72.93,87.04 71.93,86.04 70.52,86.04 67.96,83.48 67.15,83.48 63.29,79.61 62.91,79.24 62.91,65.15 71.1,56.97 71.23,56.97 71.52,57.26 71.65,57.26 71.77,57.13 71.77,57.01 71.48,56.71 71.48,56.59 71.61,56.46 71.73,56.46 72.03,56.76 72.15,56.76 72.28,56.63 72.28,56.51 71.98,56.21 71.98,56.09 72.11,55.96 72.23,55.96 72.53,56.25 72.65,56.25 72.78,56.13 72.78,56 72.49,55.71 72.49,55.58 72.61,55.46 72.74,55.46 73.03,55.75 73.16,55.75 73.28,55.63 73.28,55.5 72.99,55.21 72.99,55.08 73.11,54.95 73.24,54.95 73.53,55.25 73.66,55.25 78.18,50.73 78.18,45.86 v1(79.07,44.97)
  BOTTOM w0.114: v1(73.41,87.82) 73.37,87.82 73.06,87.5 CPU1.H31 ; v1(79.07,44.97) 78.58,44.47 DM1.186
M_A_DQ55: length 63.9
  L3 w0.089: v1(78.66,48.23) 78.66,50.68 71.49,57.86 71.36,57.86 71.04,57.53 70.91,57.53 70.79,57.66 70.79,57.78 71.11,58.11 71.11,58.23 70.98,58.36 70.86,58.36 70.54,58.04 70.41,58.04 70.28,58.16 70.28,58.29 70.61,58.61 70.61,58.73 70.48,58.86 70.35,58.86 70.03,58.54 69.91,58.54 69.78,58.66 69.78,58.79 70.1,59.11 70.1,59.24 69.98,59.36 69.85,59.36 69.53,59.04 69.4,59.04 69.28,59.17 69.28,59.29 69.6,59.62 69.6,59.74 69.47,59.87 69.35,59.87 69.03,59.54 68.9,59.54 68.78,59.67 68.78,59.8 69.1,60.12 69.1,60.24 68.97,60.37 68.85,60.37 68.52,60.05 68.4,60.05 68.27,60.17 68.27,60.3 68.59,60.62 68.59,60.75 68.47,60.87 68.34,60.87 68.02,60.55 67.9,60.55 67.77,60.68 67.77,60.8 68.09,61.12 68.09,61.25 67.97,61.38 67.84,61.38 67.52,61.05 67.39,61.05 67.27,61.18 67.27,61.3 67.59,61.63 67.59,61.75 67.46,61.88 67.34,61.88 67.02,61.56 66.89,61.56 66.76,61.68 66.76,61.81 67.09,62.13 67.09,62.26 66.96,62.38 66.83,62.38 66.51,62.06 66.39,62.06 63.18,65.26 63.18,79.13 63.4,79.35 67.31,83.26 68.08,83.26 69.04,84.23 70.63,84.23 72.01,85.61 72.01,85.74 72.62,86.36 v1(72.86,86.36)
  BOTTOM w0.114: v1(72.86,86.36) 72.9,86.39 CPU1.H32 ; DM1.187 78.83,49.68 78.71,49.57 78.71,48.28 v1(78.66,48.23)
M_A_DQ56: length 64.1
  L3 w0.089: v1(74.42,87.18) 74.04,86.8 73.99,86.8 73.75,86.55 73.75,85.12 71.25,82.61 67.59,82.61 65.08,80.1 65.08,79.3 64.18,78.4 64.18,66.89 64.37,66.7 64.49,66.7 64.79,67 64.91,67 65.04,66.87 65.04,66.75 64.74,66.45 64.74,66.33 64.87,66.2 64.99,66.2 65.29,66.5 65.42,66.5 65.54,66.37 65.54,66.24 65.25,65.95 65.25,65.82 65.37,65.7 65.5,65.7 65.79,65.99 65.92,65.99 66.04,65.87 66.04,65.74 65.75,65.45 65.75,65.32 65.87,65.19 66,65.19 66.3,65.49 66.42,65.49 66.55,65.36 66.55,65.24 66.25,64.94 66.25,64.82 66.38,64.69 66.5,64.69 66.8,64.99 66.92,64.99 67.05,64.86 67.05,64.74 66.75,64.44 66.75,64.31 80.55,50.52 80.55,50.08 80.46,49.99 80.18,49.99 80.09,49.9 80.09,49.73 80.18,49.64 80.46,49.64 80.55,49.55 80.55,48.53 80.46,48.44 79.86,48.44 79.77,48.35 79.77,48.17 79.86,48.08 80.46,48.08 80.55,47.99 80.55,47.73 v1(80.39,47.57)
  BOTTOM w0.114: DM1.195 80.83,47.98 80.41,47.57 v1(80.39,47.57) ; CPU1.L31 v1(74.42,87.18)
M_A_DQ57: length 64.7
  L3 w0.089: v1(80.04,45.04) 80.01,45.06 80.01,45.35 80.01,45.35 80.01,46.09 80.43,46.52 80.44,46.52 80.69,46.77 80.69,46.77 80.82,46.9 80.82,50.65 71.01,60.46 71.01,60.59 71.29,60.87 71.29,61 71.17,61.12 71.04,61.12 70.76,60.84 70.63,60.84 70.51,60.96 70.51,61.09 70.79,61.37 70.79,61.5 70.67,61.62 70.54,61.62 70.26,61.34 70.13,61.34 70,61.47 70,61.59 70.29,61.88 70.29,62 70.16,62.13 70.04,62.13 69.75,61.84 69.63,61.84 69.5,61.97 69.5,62.1 69.79,62.38 69.79,62.5 69.66,62.63 69.53,62.63 69.25,62.35 69.13,62.35 69,62.47 69,62.6 69.28,62.88 69.28,63.01 69.16,63.13 69.03,63.13 68.75,62.85 68.62,62.85 68.5,62.98 68.5,63.1 68.78,63.38 68.78,63.51 68.65,63.64 68.53,63.64 68.24,63.35 68.12,63.35 67.99,63.48 67.99,63.6 68.28,63.89 68.28,64.01 68.15,64.14 68.03,64.14 67.74,63.86 67.62,63.86 67.49,63.98 67.49,64.11 67.77,64.39 67.77,64.52 64.47,67.82 64.44,67.85 64.44,78.11 65.27,78.93 65.27,80.02 67.65,82.4 71.3,82.4 74.02,85.12 74.02,86.26 v1(74.17,86.41)
  BOTTOM w0.114: DM1.194 80.58,44.5 v1(80.04,45.04) ; v1(74.17,86.41) 74.18,86.41 CPU1.L32
M_A_DQ58: length 62.8
  L3 w0.089: v1(75.29,89.2) 75.64,88.86 75.64,87.66 75.41,87.43 75.41,86.9 75.06,86.55 75.06,86 75.28,85.78 75.28,84.98 73.92,83.62 73.92,82.93 72.72,81.74 68.18,81.74 65.99,79.55 65.99,78.27 65.37,77.65 65.37,68.32 65.43,68.25 65.43,68.23 75.15,58.51 75.15,57.65 81.75,51.05 81.75,46.52 82.04,46.23 82.04,45.47 82.81,44.71 83.26,44.71 v1(83.57,45.01)
  BOTTOM w0.114: v1(75.29,89.2) 75.69,88.8 CPU1.N29 ; DM1.204 83.08,44.52 v1(83.57,45.01)
M_A_DQ59: length 62.9
  L3 w0.089: v1(83.57,46.28) 82.89,46.28 82.09,47.08 82.09,51.09 75.42,57.76 75.42,58.65 65.64,68.43 65.64,77.43 66.21,78 66.21,79.5 68.23,81.52 72.78,81.52 74.11,82.85 74.11,83.48 75.47,84.84 75.47,85.86 75.25,86.08 75.25,86.47 75.6,86.82 75.6,87.35 75.83,87.58 75.83,88.93 75.74,89.02 75.74,89.39 v1(75.3,89.84)
  BOTTOM w0.114: DM1.208 84.08,45.77 v1(83.57,46.28) ; v1(75.3,89.84) 75.3,89.84 75.37,89.84 75.75,89.46 CPU1.N28
M_A_DQ60: length 60.8
  L3 w0.089: v1(78.61,46.96) 78.62,46.96 79.08,47.42 79.08,51.23 63.64,66.67 63.64,79.21 67.48,83.05 70.44,83.05 73.31,85.91 73.31,86.72 73.81,87.22 73.81,88.84 73.87,88.9 73.87,89.26 v1(74.36,89.75)
  BOTTOM w0.089: CPU1.L28 74.53,89.75 v1(74.36,89.75)
  BOTTOM w0.114: v1(78.61,46.96) 78.64,46.96 79.52,47.84 79.52,48.52 79.83,48.83 DM1.191
