# Allegro board 18750-1.1227WZS1652.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
1V_VCCGT on L3: 71.2,121.26 75.97,116.49 75.97,114.78 76.63,114.12 76.63,111.71 77.98,110.36 77.98,101.27 78.24,101.02 78.24,100.97 82.17,97.03 82.17,93.42 82.02,93.27 64.87,93.27 64.39,93.75 64.39,105.08 65.66,106.35 65.66,111.69 63.76,113.59 63.76,127.18 64.49,127.92 70.62,127.92 71.2,127.33
1V_VCCIO on TOP: 97.03,89.46 96.9,89.59 96.9,89.94 96.73,90.12 95.68,90.12 95.56,90.25 95.56,90.65 95.68,90.78 97.67,90.78 97.82,90.93 97.82,91.39 97.4,91.81 97.17,91.81 97.01,91.97 97.01,92.15 97.18,92.33 98.15,92.33 98.28,92.2 98.28,91.54 98.43,91.39 98.43,89.59 98.3,89.46 ; 2 cut-outs
1V_VCCIO on TOP: 85.98,89.59 85.86,89.71 85.86,90.73 85.73,90.86 84.41,90.86 84.2,91.06 84.2,91.47 84.64,91.9 84.64,92.64 84.79,92.79 85.52,92.79 86.68,91.63 86.68,91.48 87.76,90.4 87.76,89.71 87.63,89.59 ; 3 cut-outs
1V_VCCIO on TOP: 106.68,123.75 106.56,123.88 106.56,124.99 106.71,125.15 107.09,125.15 107.19,125.25 107.19,125.6 107.57,125.99 107.57,127.18 107.32,127.43 107.32,129.97 108.08,130.74 108.21,130.74 108.97,129.97 108.97,127.18 109.48,126.67 109.48,126.04 109.12,125.68 109.12,124.84 108.97,124.69 108.66,124.69 108.46,124.49 108.46,123.88 108.33,123.75 ; 7 cut-outs
1V_VCCIO on BOTTOM: 107.45,128.04 107.22,128.27 107.22,129.92 107.9,130.61 108.28,130.61 108.49,130.4 108.49,129.11 108.61,128.98 108.61,128.63 108.03,128.04
1V_VCCIO on BOTTOM: 97.13,89.64 97.07,89.7 97.07,90.36 97.06,90.37 97.06,92.18 97.21,92.33 98.12,92.33 98.33,92.13 98.33,89.69 98.28,89.64
1V_VCCIO on BOTTOM: 86.06,89.59 86.01,89.64 86.01,90.12 86.03,90.15 86.03,91.34 85.58,91.8 85.58,92.05 85.68,92.15 86.95,92.15 87.79,91.31 87.79,89.82 87.56,89.59
1V_VCCIO on L2GND: 85.93,89.65 85.79,89.79 85.79,91.44 85.54,91.7 85.54,92.18 85.68,92.32 94.32,92.32 95.19,93.19 95.19,98.53 95.7,99.03 95.7,99.56 100.79,99.56 101.05,99.81 103.71,99.81 104.33,100.43 104.33,123.16 104.97,123.8 104.97,124.31 105.6,124.94 105.6,129.51 106.76,130.67 108.38,130.67 109.16,129.89 109.16,129.52 108.65,129.01 108.65,126.97 109.67,125.96 109.67,123.83 108.98,123.14 108.98,119.4 109.29,119.1 109.29,118.08 113.34,114.03 113.84,114.03 114.37,113.51 114.37,113 115.64,111.73 115.64,109.07 116.78,107.92 116.78,102.11 116.14,101.48 116.14,98.14 116.91,97.38 116.91,96.4 116.65,96.14 116.65,92.21 115.24,90.79 111.94,90.79 111.56,90.41 109.37,90.41 109.3,90.34 108.72,90.34 108.64,90.41 98.73,90.41 98.36,90.05 98.36,89.67 98.35,89.65
1V_VCCIO on L5: 86.11,89.46 87.25,89.46 88.01,90.22 96.52,90.22 96.9,89.84 96.9,89.59 97.03,89.46 98.3,89.46 98.43,89.59 98.43,92.15 97.89,92.69 86.34,92.69 85.6,91.95 85.6,89.97
1V_VCCIO on L6: 86.11,89.46 87.25,89.46 88.01,90.22 96.52,90.22 96.9,89.84 96.9,89.59 97.03,89.46 98.3,89.46 98.43,89.59 98.43,92.1 101.73,95.4 101.73,96.62 101.48,96.88 100.05,96.88 95.84,92.66 86.31,92.66 85.65,92 85.65,89.92
1V_VCCSA on TOP: 98.56,89.59 98.56,91.47 98.43,91.59 98.43,92.28 98.15,92.56 97.34,92.56 97.11,92.79 97.11,99.29 96.78,99.62 96.52,99.62 96.27,99.87 96.27,100.53 96.19,100.61 95.48,100.61 95.18,100.92 95.18,101.4 95.25,101.47 95.76,101.47 96.05,101.77 96.05,104.09 96.65,104.69 96.65,106.99 95,108.64 95,111.56 90.43,116.13 90.43,121.34 89.92,121.85 89.92,124.39 89.79,124.51 89.79,128.58 89.92,128.7 96.02,128.7 96.4,128.32 96.4,115.75 99.7,112.45 99.7,101.65 99.75,101.6 99.75,96.7 99.47,96.42 99.47,93.35 100.26,92.56 100.26,92.03 100.18,91.95 99.29,91.95 99.19,91.85 99.19,90.45 99.39,90.25 99.39,89.66 99.32,89.59 ; 18 cut-outs
1V_VCCSA on BOTTOM: 98.73,89.54 98.43,89.84 98.43,92.25 98.81,92.64 100.21,92.64 100.59,92.25 100.59,90.98 100.49,90.88 99.32,90.88 99.14,90.7 99.14,89.89 99.19,89.84 99.19,89.66 99.06,89.54
1V_VCCSA on BOTTOM: 90.2,124.23 89.92,124.51 89.92,128.07 89.93,128.08 89.93,128.46 90.05,128.58 94.08,128.58 94.25,128.74 94.29,128.7 96.14,128.7 96.42,128.42 96.42,127.97 96.4,127.94 96.4,124.28 96.35,124.23
1V_VCCSA on BOTTOM: 96.5,99.87 96.29,100.08 96.29,100.89 96.65,101.25 96.65,102.16 96.78,102.29 99.32,102.29 99.7,101.91 99.7,101.27 100.08,100.89 100.08,100 99.95,99.87
1V_VCCSA on L2GND: 95.7,99.94 95.7,100.94 95.95,101.19 95.95,106.3 94.94,107.32 94.94,111.26 93.43,112.76 92.67,112.76 90.76,114.67 89.11,114.67 88.71,115.07 88.71,118.24 88.35,118.61 86.95,118.61 86.81,118.75 86.81,125.7 87.57,126.47 87.57,127.99 88.35,128.77 92.76,128.77 93.02,128.51 94.19,128.51 94.7,129.02 100.25,129.02 102.79,126.48 104.7,126.48 105.22,125.96 105.22,125.1 104.59,124.46 104.59,123.96 103.95,123.32 103.95,100.59 103.56,100.19 100.89,100.19 100.64,99.94
1V_VCCSA on L3: 89.54,128.7 89.54,118.16 94.53,113.17 94.53,112.54 95,112.07 95,108.74 96.55,107.19 96.55,106.58 95.76,105.79 95.76,91.75 97.92,89.59 99.34,89.59 99.44,89.69 99.44,89.94 99.67,90.17 100.26,90.17 100.59,90.5 100.59,92.25 100.08,92.76 100.08,101.27 99.7,101.65 99.7,117.53 99.44,117.78 98.43,117.78 96.52,119.69 96.52,128.45 96.27,128.7
1V_VCCST_CPU on TOP: 96.83,115.37 96.32,115.88 96.32,117.35 96.4,117.43 96.85,117.43 96.88,117.4 96.88,116.43 96.93,116.38 96.93,116.13 97.34,115.72 97.34,115.6 97.11,115.37
1V_VCCST_CPU on TOP: 82.93,151.06 82.53,151.46 78.87,151.46 78.77,151.56 78.77,151.99 78.87,152.1 83.92,152.1 84.43,152.6 84.74,152.6 84.86,152.48 84.86,151.28 84.79,151.21 84.18,151.21 84.03,151.06 ; 2 cut-outs
1V_VCCST_CPU on TOP: 100.79,100.46 100.23,101.02 100.23,104.45 100.46,104.67 100.74,104.67 101.68,103.73 101.68,101.47 102.31,100.84 102.31,100.61 102.16,100.46
1V_VCCST_CPU on BOTTOM: 100.92,100.1 100.74,100.28 100.74,100.92 100.87,101.04 102.19,101.04 102.52,100.71 102.52,100.2 102.42,100.1
1V_VCCST_CPU_R on TOP: 116.61,114.81 116.23,115.19 116.23,115.65 115.55,116.33 114.38,116.33 114.28,116.43 114.28,117.98 114.35,118.06 116.49,118.06 116.89,117.65 116.89,116 117.02,115.88 117.25,115.88 117.45,115.67 117.45,114.89 117.38,114.81 ; 1 cut-out
1V_VCCSTG on BOTTOM: 96.63,105.01 96.39,105.25 96.39,106.74 95.86,107.27 95.86,107.55 95.95,107.64 96.57,107.64 97.1,107.12 97.1,105.17 96.94,105.01
1V_VGA_CORE on TOP: outline of 88 points within 119.76,97.84 152.86,134.42 ; 39 cut-outs
1V_VGA_CORE on BOTTOM: 140.84,94.6 140.41,95.04 140.41,98.13 140.79,98.52 143.3,98.52 143.77,98.99 143.77,107.37 144.02,107.62 150.07,107.62 150.63,107.06 150.63,98.35 151.26,97.72 152.4,97.72 152.61,97.51 152.61,94.6 ; 1 cut-out
1V_VGA_CORE on BOTTOM: 133.83,124.45 133.83,123.8 129.68,119.65 128.97,119.65 128,118.68 127.87,118.68 119.76,126.79 119.71,126.79 118.75,127.76 118.75,128.32 119.64,129.21 119.66,129.21 119.76,129.31 121.57,129.31 123.93,131.67 126.43,131.67 132.79,138.03 134.41,138.03 134.68,137.76 134.68,137.76 135.86,136.57 135.86,136.57 139.54,132.89 139.54,131.86 139.34,131.66 139.34,130.65 136.67,127.98 136.67,127.28 ; 11 cut-outs
1V_VGA_CORE on L2GND: 140.98,96.33 140.53,96.78 140.53,104.91 118.56,126.88 118.56,127.86 119.08,128.39 119.43,128.39 119.46,128.36 121.11,128.36 124.54,131.79 126.9,131.79 132.54,137.43 134.65,137.43 139.23,132.84 139.23,130.76 137.18,128.71 137.18,126.47 133.39,122.69 133.39,121.08 139.39,115.09 139.39,112.11 143.1,108.4 148.62,108.4 150.97,106.04 150.97,103.23 150.38,102.65 150.38,97.36 149.35,96.33
1V_VGA_CORE on L3: 136.93,135.27 138.42,133.78 138.42,132.41 135.1,129.09 135.1,123.63 136.99,121.74 139.65,121.74 147.68,113.72 147.68,112.98 154.44,106.22 154.44,93.91 154.18,93.65 154.18,93.57 140.85,93.57 140.31,94.11 140.31,96.62 140.31,96.62 140.31,103.36 140.33,103.37 140.33,104.59 140.26,104.65 140.26,106.1 120.68,125.68 120.68,127.97 122.43,129.72 123.83,129.72 124.46,130.35 125.35,130.35 125.73,130.74 125.73,130.84 132.34,137.44 133.86,137.44 136.03,135.27
1V_VGA_S0 on TOP: 133.99,146.48 133.73,146.74 133.73,151.69 133.89,151.84 134.62,151.84 134.9,151.56 135.41,151.56 135.77,151.21 135.77,147.88 135.64,147.75 135.64,147.37 134.75,146.48 ; 1 cut-out
1V_VGA_S0 on TOP: 118.37,142.55 118.24,142.67 118.24,144.37 118.27,144.4 121.08,144.4 121.54,143.94 121.54,142.8 121.29,142.55
1V_VGA_S0 on BOTTOM: 134.09,140.41 133.94,140.56 133.94,145.59 134.45,146.1 134.45,148.26 133.71,149 131.19,149 130.86,149.33 130.86,149.48 131.12,149.73 131.12,150.19 131.7,150.78 132.21,150.78 132.54,151.11 134.65,151.11 135.77,149.99 135.77,147.68 134.95,146.86 134.95,145.9 134.45,145.39 134.45,140.51 134.34,140.41 ; 3 cut-outs
1V_VGA_S0 on BOTTOM: 118.37,142.17 118.11,142.42 118.11,143.89 118.42,144.2 122.61,144.2 122.71,144.1 122.71,143.26 121.62,142.17 ; 5 cut-outs
1V_VGA_S0 on L3: 122.15,145.29 125.17,148.31 125.53,148.31 128.53,151.31 133.56,151.31 135.87,149 135.87,148.03 135.56,147.73 135.56,147.17 134.8,146.41 134.8,143.79 134.32,143.31 133.33,143.31 132.86,143.78 132.86,147.46 131.35,148.97 130.33,148.97 127.54,146.18 127.54,143.82 120.96,137.24 120.4,137.24 118.49,139.14 118.49,140.74 118.51,140.76 118.51,144.39 119.41,145.29 ; 1 cut-out
3V_5V_POK on BOTTOM: 39.4,36.37 39.37,36.4 39.37,37.59 39.55,37.77 39.8,37.77 40,37.58 40,37.15 40.36,36.78 40.36,36.42 40.31,36.37
5V_3V_TPAN_PWR on BOTTOM: 154.54,105.54 154.51,105.57 154.51,107.52 154.74,107.75 155.17,107.75 155.35,107.57 156.62,107.57 156.9,107.29 156.9,106.12 156.82,106.05 156.21,106.05 156.06,106.2 156.06,106.68 155.81,106.94 155.4,106.94 155.14,106.67 155.14,105.65 155.03,105.54 ; 1 cut-out
5V_FAN_VCC on TOP: 158.35,88.29 158.25,88.39 158.25,89.59 158.32,89.66 158.83,89.66 158.88,89.61 158.88,89.13 159.06,88.95 160.2,88.95 160.35,88.8 160.35,88.39 160.25,88.29
5V_HDD_S0 on TOP: 156.75,36.68 156.59,36.83 156.59,39.17 156.85,39.42 159.26,39.42 159.52,39.68 159.52,40.31 159.77,40.57 161.93,40.57 162.18,40.31 162.18,38.41 161.78,38 161.04,38 160.56,37.52 159.26,37.52 158.42,36.68 ; 4 cut-outs
5V_HDD_S0 on BOTTOM: 159.49,38.1 159.49,39.93 159.74,40.18 161.55,40.18 161.8,39.93 161.8,38.1
5V_ODD_S0 on TOP: 183.37,33.83 183.21,33.99 183.21,34.84 183.29,34.91 189.98,34.91 190.6,34.29 190.6,34.01 190.43,33.83 187.61,33.83 187.56,33.88 186.74,33.88 186.69,33.83 ; 6 cut-outs
5V_ODD_S0 on BOTTOM: 190.26,33.77 190.12,33.91 190.12,34.11 189.94,34.29 188.27,34.29 187.96,33.99 185.45,33.99 185.37,34.06 185.37,34.9 186.01,35.54 187.91,35.54 188.39,36.02 190.02,36.02 190.66,35.38 190.66,33.96 190.46,33.77
5V_S0 on TOP: 34.29,14.91 34.22,14.99 34.22,18.44 34.14,18.52 34.14,19.94 34.24,20.04 34.93,20.04 35.64,19.33 35.64,15.27 35.28,14.91
5V_S0 on TOP: 175.77,31.17 175.71,31.23 174.12,31.23 174.12,31.23 173.74,31.23 173.74,31.24 154.74,31.24 154.44,31.55 154.44,36.3 154.51,36.37 158.19,36.37 158.27,36.3 158.27,34.14 158.96,33.45 170.49,33.45 171.96,34.93 175.47,34.93 176.14,34.25 181.75,34.25 182.88,33.12 185.25,33.12 185.32,33.05 188.19,33.05 188.27,33.12 190.58,33.12 190.76,32.95 190.76,31.42 190.5,31.17 ; 7 cut-outs
5V_S0 on TOP: 60.68,35.97 60.61,36.04 60.61,37.11 60.89,37.39 63.22,37.39 63.48,37.14 63.48,36.17 63.27,35.97 ; 1 cut-out
5V_S0 on BOTTOM: 204.35,58.09 204.22,58.22 204.22,60.63 204.12,60.73 204.12,61.09 204.88,61.85 204.88,63.53 204.8,63.6 196.27,63.6 195.38,64.49 195.38,65.2 196.07,65.89 204.57,65.89 206.1,64.36 206.1,58.83 205.36,58.09
5V_S0 on BOTTOM: 60.38,36.07 60.28,36.17 60.28,37.16 60.94,37.16 61.19,37.42 62.16,37.42 62.28,37.54 62.28,38.41 62.61,38.74 63.83,38.74 64.01,38.56 64.01,36.22 63.86,36.07 ; 3 cut-outs
5V_S0 on L2GND: 33.99,18.4 33.85,18.55 33.85,22.2 42.12,30.47 51.14,30.47 56.85,36.18 59.77,36.18 60.26,36.68 60.26,37.69 60.53,37.96 62.28,37.96 62.55,37.69 62.55,36.83 60.88,35.17 57.33,35.17 55.69,33.53 55.69,32.01 51.49,27.8 41.58,27.8 35.75,21.98 35.75,18.67 35.48,18.4
5V_S0 on L3: 32.67,27.28 32.95,27.56 33.76,27.56 33.89,27.43 33.89,26.29 34.97,25.21 34.97,18.51 34.88,18.42 34.17,18.42 34.01,18.57 34.01,24.39 32.67,25.73
5V_S0 on L6: 63.4,37.19 63.4,35.41 63.2,35.21 60.89,35.21 60.58,35.51 60.58,37.19 60.79,37.39 63.2,37.39
5V_S0 on L6: 199.33,33.14 199.48,33.29 205.86,33.29 205.9,33.25 206.96,33.25 208.28,31.93 208.28,31.42 208.03,31.17 207.27,31.17 207.27,31.17 189.89,31.17 189.74,31.32 189.74,33.07 190.12,33.45 192.28,33.45 192.6,33.14
5V_S0 on L7GND: 151.09,33.52 150.82,33.79 150.82,36.07 150.32,36.56 149.15,36.56 148.13,35.55 142.96,35.55 141.56,36.95 118.7,36.95 118.43,37.22 118.43,37.72 117.94,38.22 114.22,38.22 112.19,36.18 105.62,36.18 103.59,38.22 98.48,38.22 98.35,38.09 83.24,38.09 82.09,36.95 63.81,36.95 63.55,36.69 59.9,36.69 59.38,37.22 59.38,40.76 96.73,40.76 97.22,41.25 97.22,42.39 98.62,43.79 98.62,44.42 99.27,45.07 102.67,45.07 103.94,43.8 105.84,43.8 106.49,43.15 106.49,42.52 107.24,41.77 143.31,41.77 143.69,41.39 144.61,41.39 144.99,41.77 145.72,41.77 145.85,41.64 152.45,41.64 156.01,38.09 157.4,38.09 157.67,37.82 157.67,33.66 157.53,33.52
5V_S5 on TOP: 110.37,28.35 109.85,28.87 109.85,29.78 110.32,30.25 111.43,30.25 111.53,30.15 111.53,29.64 111.2,29.31 111.2,28.6 110.95,28.35 ; 3 cut-outs
5V_S5 on TOP: 16.25,23.61 15.92,23.94 15.92,28.82 16.54,29.44 19,29.44 22.25,32.69 24.41,32.69 25.48,31.62 25.48,30.07 23.27,27.87 22.88,27.87 22.39,27.38 22.39,24.98 21.77,24.36 19.97,24.36 19.22,23.61 ; 2 cut-outs
5V_S5 on TOP: 43.79,121.62 43.72,121.69 43.72,122.81 43.16,123.37 43.11,123.37 42.98,123.5 42.98,124.23 43.13,124.39 43.44,124.39 43.56,124.51 43.56,125.17 43.79,125.4 45.22,125.4 45.47,125.66 46.38,125.66 46.46,125.58 46.46,125.32 46.41,125.27 45.8,125.27 45.24,124.72 45.11,124.72 44.96,124.56 44.96,124 45.14,123.83 45.34,123.83 45.47,123.7 45.47,122.91 44.94,122.38 44.94,121.87 44.68,121.62 ; 3 cut-outs
5V_S5 on TOP: 48.77,38.89 48.11,39.55 48.11,40.08 49.15,41.12 50.19,41.12 51.18,40.13 51.18,39.8 50.27,38.89
5V_S5 on TOP: 18.42,33.48 18.27,33.63 18.27,38.61 19.31,39.65 20.27,39.65 21.59,40.97 21.59,44.22 22.3,44.93 22.3,47.6 23.17,48.46 23.17,50.14 23.55,50.52 23.55,51.06 23.78,51.28 23.78,52.02 23.49,52.31 23.05,52.31 22.63,52.73 21.42,52.73 21.34,52.81 21.34,53.44 21.39,53.49 22.74,53.49 23.4,54.15 25.35,54.15 25.57,53.94 26.3,53.94 26.88,53.37 26.88,50.57 26.57,50.27 26.57,48.11 26.62,48.06 26.62,43.84 26.44,43.66 26.44,41.83 25.93,41.32 25.92,41.32 25.52,40.92 25.52,37.38 25.06,36.92 23.82,36.92 23.4,37.34 22.3,37.34 20.3,35.33 20.3,33.76 20.02,33.48 ; 1 cut-out
5V_S5 on TOP: 74.04,136.48 73.87,136.65 73.87,137.64 74.15,137.92 74.15,139.42 74.32,139.6 75.01,139.6 75.03,139.57 75.03,138.89 74.93,138.79 74.93,136.58 74.83,136.48 ; 1 cut-out
5V_S5 on TOP: 190.78,34.47 190.77,34.48 190.63,34.48 190.06,35.05 183.29,35.05 180.95,37.39 174.25,37.39 173.87,37.77 169.98,37.77 169.17,38.58 169.17,39.7 169.65,40.18 169.68,40.18 170.11,40.62 172.29,40.62 172.66,40.25 175.43,40.25 175.72,39.95 183.39,39.95 185.19,38.15 185.22,38.15 185.55,37.82 187.43,37.82 187.72,37.53 190.36,37.53 191.11,36.78 194.85,36.78 194.97,36.65 194.97,34.77 194.67,34.47 ; 4 cut-outs
5V_S5 on TOP: 94.67,32.34 93.4,33.61 93.4,38.33 94.15,39.08 96.35,39.08 96.66,39.39 97.84,39.39 98.28,39.83 98.66,39.83 98.78,39.7 98.78,39.09 99.29,38.58 99.29,37.47 98.76,36.93 97.87,36.93 97.79,37.01 97.79,37.57 97.67,37.69 97.01,37.69 96.76,37.45 96.76,33.97 96.57,33.78 95.81,33.78 95.33,33.3 95.33,32.54 95.13,32.34 ; 2 cut-outs
5V_S5 on BOTTOM: 16.34,23.6 15.47,24.46 15.47,28.32 16.18,29.03 19.15,29.03 21.06,30.94 24.01,30.94 24.18,31.12 25.35,31.12 25.53,30.94 25.53,30.15 24.92,29.54 22,29.54 18.63,26.18 18.15,26.18 17.86,25.88 17.86,23.9 17.55,23.6
5V_S5 on BOTTOM: 48.87,35.61 48.24,36.25 48.24,40.13 48.31,40.2 48.93,40.2 48.93,40.21 56.44,40.21 56.81,39.84 56.81,38.73 56.81,38.72 57.32,38.72 58,38.04 58.27,38.04 58.28,38.05 58.3,38.03 58.91,38.03 58.91,36.17 58.8,36.07 56.7,36.07 55.88,36.88 55.17,36.88 54.91,37.14 53.93,37.14 53.68,36.88 51.71,36.88 51.51,36.68 51.51,36.68 51.39,36.55 51.39,35.77 51.23,35.61 ; 16 cut-outs
5V_S5 on BOTTOM: 156.87,105.5 156.87,105.24 156.86,105.22 156.1,105.22 155.48,104.6 155.48,103.61 155.27,103.4 154.54,103.4 154.44,103.51 154.44,105.23 154.52,105.32 154.52,105.32 154.56,105.36 155.42,105.36 155.61,105.55 156.82,105.55 ; 1 cut-out
5V_S5 on BOTTOM: 98.43,135.71 98.35,135.79 98.35,136.04 98.4,136.09 99.01,136.09 99.08,136.16 99.08,136.41 99.6,136.93 99.6,137.34 99.34,137.59 98.4,137.59 98.35,137.64 98.35,139.12 98.91,139.68 98.91,140.26 98.96,140.31 99.83,140.31 99.98,140.16 99.98,137.19 100.21,136.96 100.61,136.96 100.76,136.81 100.76,136.48 100.74,136.45 100.03,136.45 100,136.48 99.52,136.48 99.34,136.3 99.34,135.87 99.19,135.71 ; 1 cut-out
5V_S5 on BOTTOM: 17.76,33.5 17.52,33.75 17.52,36.59 18.46,37.53 18.46,39.71 18.74,39.99 19.93,39.99 20.18,39.74 20.77,39.74 20.96,39.55 20.96,36.73 20.51,36.29 20.51,34.86 19.15,33.5 ; 1 cut-out
5V_S5 on BOTTOM: 193.32,35.18 193.12,35.38 193.12,38.79 193.4,39.07 195.46,39.07 195.46,35.36 195.28,35.18
5V_S5 on BOTTOM: 19.68,121.02 19.13,121.57 19.13,122.87 19.61,123.36 20.26,123.36 20.87,123.97 24.45,123.97 25.44,124.96 25.44,126.56 27,128.12 35.97,128.12 35.99,128.09 41.86,128.09 44.71,125.25 44.71,123.37 44,122.66 42.34,122.66 42.33,122.67 41.82,122.67 41.33,123.17 38.48,123.17 38.42,123.23 31.75,123.23 30.78,124.21 29.57,124.21 29.29,123.93 29.29,122.84 27.47,121.02
5V_S5 on L2GND: 16.72,23.36 16.32,23.75 16.32,27.82 16.07,28.07 16.07,28.68 16.47,29.07 19.01,29.07 21.4,31.47 21.4,31.72 22.18,32.5 24.31,32.5 25.34,31.47 25.34,29.98 24.69,29.33 23.8,29.33 22.04,27.56 22.04,24.9 21.77,24.63 20.12,24.63 18.85,23.36
5V_S5 on L3: 108.46,32.18 108.97,31.68 110.95,31.68 112.27,30.35 113.34,30.35 114.1,29.59 114.1,28.65 114.23,28.53 116.44,28.53 116.98,29.07 116.98,30.37 118.29,31.68 119.59,31.68 122.43,34.52 129.97,34.52 130.18,34.32 130.18,32.82 129.92,32.56 125.12,32.56 125.11,32.55 124.07,32.55 120.6,29.08 118.98,29.08 117.3,27.41 113.62,27.41 112.47,28.55 110.32,28.55 109.45,29.41 108.72,29.41 107.04,31.09 95.23,31.09 94.8,31.52 94.8,32.84 94.95,33 95.3,33 95.46,32.84 95.46,32.46 95.74,32.18
5V_S5 on L3: 15.42,87.61 13.95,89.08 13.95,92.69 14.51,93.24 14.51,99.09 13.96,99.63 13.96,105.47 8.94,110.49 8.94,114.45 10,115.51 10,116.12 12.6,118.72 13.21,118.72 14.74,120.24 16.28,120.24 17.82,121.78 18.48,121.78 19.36,122.66 20.98,122.66 24.9,118.75 24.9,112.55 23.04,110.69 17.25,110.69 15.78,112.17 14.43,112.17 14.1,111.84 14.1,110.54 15.37,109.27 16.39,109.27 17.81,107.85 17.81,100 18.82,98.99 18.82,89.13 17.96,88.27 17.96,88.24 17.33,87.61
5V_S5 on L5: 12.14,113.44 12.14,110.82 11.23,109.91 11.23,108.41 12.02,107.62 12.7,107.62 15.12,105.21 15.12,92.79 15.29,92.61 15.29,87.81 15.4,87.71 17.81,87.71 18.72,88.62 18.72,94.06 19.15,94.49 19.15,101.8 18.01,102.95 18.01,107.52 16.65,108.88 16.65,112.87 15.79,113.73 12.44,113.73
5V_S5 on L6: 82.86,148.77 82.57,149.06 82.57,150.51 82.86,150.8 83.57,150.8 84.5,149.87 85.23,149.87 86.46,148.64 86.46,148.21 85.98,148.21 85.42,148.77
5V_S5 on L6: 165.71,37.11 165,36.4 160.73,36.4 160.02,37.11 158.37,37.11 156.52,35.26 149.69,35.26 149.46,35.49 149.46,36.3 149.91,36.76 155.86,36.76 157.23,38.13 168.05,38.13 169.78,39.85 171.07,39.85 171.28,39.65 171.28,39.27 169.12,37.11
5V_S5 on L6: 13.97,28.78 13.97,32.36 13.34,33 13.34,38.91 10.8,41.45 10.8,45.52 13.34,48.06 13.34,49.33 13.72,49.71 13.72,49.81 13.85,49.94 13.85,64.06 13.16,64.75 13.16,68.2 13.8,68.84 13.8,69.83 21.92,77.95 31.35,77.95 31.91,77.4 36.4,77.4 36.54,77.53 36.6,77.53 37.06,77.99 38.29,77.99 38.46,78.16 38.46,90.63 37.98,91.11 25.73,91.11 22.15,87.53 15.6,87.53 15.37,87.76 15.37,89.84 15.73,90.2 15.75,90.2 17.05,91.49 19.82,91.49 21.09,92.76 21.09,94.54 21.59,95.05 23.5,95.05 24.13,95.68 24.13,96.45 25.78,98.1 35.69,98.1 36.71,97.08 36.71,95.18 37.72,94.16 40.01,94.16 42.07,92.1 42.07,76.66 38.76,73.36 29.29,73.36 29.01,73.08 27.16,73.08 26.11,72.04 25.4,72.04 23.16,69.79 22.42,69.79 21.34,68.71 21.34,68.43 20.45,67.54 20.45,67.08 19.92,66.55 19.92,60.91 18.42,59.41 18.42,36.42 19.76,35.08 19.76,24.21 19.15,23.6 15.09,23.6 13.26,25.43 13.26,28.07
5V_S5 on L6: 34.42,37.21 30.66,33.45 24.54,33.45 22.84,31.75 22.84,29.77 23.8,28.8 34.01,28.8 35.89,30.68 38.26,30.68 40.08,32.51 52.45,32.51 55.1,35.15 58.58,35.15 58.93,35.51 58.93,40.55 55.95,43.54 36.43,43.54 34.42,41.53 ; 1 cut-out
5V_S5 on L7GND: 100.41,27.29 95.33,32.37 95.08,32.37 94.68,32.77 94.68,33.02 93.05,34.66 82.6,34.66 82.09,34.15 81.74,34.15 81.49,34.41 52.53,34.41 47.69,39.25 47.69,40.11 48.34,40.76 58.98,40.76 58.99,40.74 58.99,37.06 59.74,36.31 63.71,36.31 63.96,36.56 82.25,36.56 83.39,37.71 97.08,37.71 97.6,37.18 97.6,36.17 98.24,35.53 98.24,33.63 101.02,30.85 106.13,30.85 106.51,31.23 111.05,31.23 112.45,29.83 112.7,29.83 113.22,29.31 113.22,29.06 113.84,28.44 117.05,28.44 117.8,29.18 117.8,30.96 118.43,31.6 118.43,36.3 118.7,36.56 141.4,36.56 142.8,35.17 148.29,35.17 149.31,36.18 150.17,36.18 150.43,35.91 150.43,33.63 150.93,33.14 157.69,33.14 158.05,33.5 158.05,37.82 158.32,38.09 167.47,38.09 169.25,39.87 171.37,39.87 171.52,39.72 171.52,39.37 168.93,36.79 168.11,36.44 166.04,36.44 165.66,36.06 161.6,36.06 160.34,34.8 160.34,32.64 159.06,31.36 128.86,31.36 126.83,33.39 124.51,33.39 122.75,31.63 122.75,27.94 122.1,27.29
5V_S5 on L7GND: 16.34,23.74 15.56,24.52 15.56,38.2 17.1,39.74 20.37,39.74 21.02,39.09 21.02,25.91 18.85,23.74
5V_TPAN_PWR on TOP: 159.08,106.35 158.8,106.63 158.8,108.13 158.91,108.23 160.43,108.23 160.53,108.13 160.53,106.66 160.23,106.35
5V_TPAN_PWR on BOTTOM: 158.17,106.07 158.12,106.12 158.12,106.94 158.27,107.09 159.34,107.09 159.41,107.01 159.41,106.55 158.93,106.07
5V_TPAN_VDD on TOP: 158.93,108.71 158.8,108.84 158.8,109.81 158.83,109.83 161.04,109.83 161.14,109.73 161.14,108.81 161.04,108.71
5V_TPAN_VDD on BOTTOM: 158.88,108.15 158.8,108.23 158.8,109.09 159.01,109.3 160.96,109.3 161.06,109.2 161.06,108.26 160.96,108.15 ; 2 cut-outs
5V_TPAN_VDD on L6: 175.01,74.65 175.92,74.65 176.84,73.74 176.84,73.59 176.2,72.95 175.77,72.95 174.83,73.89 174.83,74.47
5V_USB30_VCCA on TOP: 15.19,32.34 12.35,35.18 12.35,35.64 14.23,37.52 17.88,37.52 17.94,37.47 17.94,33.02 17.25,32.34
5V_USB30_VCCA on BOTTOM: 15.73,35.82 15.5,36.04 15.5,38.08 15.8,38.38 15.8,39.09 16.36,39.65 16.36,39.83 16.46,39.93 17.3,39.93 17.4,39.83 17.4,38.66 17.3,38.56 17.3,35.94 17.17,35.82 ; 3 cut-outs
5V_VCONN_P1 on TOP: 48.77,124.13 48.64,124.26 48.64,125.17 48.52,125.3 47.91,125.3 47.86,125.35 47.86,126.09 47.91,126.14 49.05,126.14 49.28,125.91 49.28,124.16 49.25,124.13
19V_AD+ on TOP: 30.23,128.2 30.1,128.32 30.1,131.62 30,131.73 29.24,131.73 28.91,132.06 28.91,132.36 28.98,132.44 29.16,132.44 29.52,132.79 29.52,133.88 29.8,134.16 30.74,134.16 30.76,134.14 30.76,133.45 30.94,133.28 32.72,133.28 32.85,133.15 32.85,132.69 32.95,132.59 33.48,132.59 33.81,132.26 33.81,131.75 34.04,131.52 36.43,131.52 36.45,131.5 36.45,129.08 36.2,128.83 32.9,128.83 32.77,128.7 32.77,128.32 32.64,128.2 ; 4 cut-outs
20V_DCBATOUT on BOTTOM: 191.65,52.76 190.27,54.13 190.27,56.19 190.15,56.31 186.82,56.31 186.69,56.19 186.69,55.42 186.62,55.35 185.5,55.35 185.35,55.5 185.35,57.48 185.25,57.58 185.25,60.76 191.6,60.76 191.8,60.55 191.8,59.36 191.85,59.31 193.63,59.31 194.14,58.8 194.14,55.53 194.29,55.37 195.08,55.37 195.2,55.25 195.2,52.88 195.08,52.76
20V_VCCPD_VBUS on TOP: 39.7,122.38 39.6,122.48 39.6,123.7 39.42,123.88 39.12,123.88 38.87,124.13 38.87,127.69 40.39,129.21 48.26,129.21 48.9,128.58 49.66,128.58 49.74,128.5 49.74,126.67 49.61,126.54 41.76,126.54 41.66,126.44 41.66,124.56 41.82,124.4 41.82,123.92 41.99,123.75 42.29,123.75 42.34,123.7 42.34,123.42 42.29,123.37 40.64,123.37 40.52,123.5 40.52,124.26 40.39,124.39 40.03,124.39 39.96,124.31 39.96,122.48 39.86,122.38 ; 4 cut-outs
20V_VCCPD_VBUS on BOTTOM: 10.49,117.78 10.39,117.88 10.39,118.95 10.62,119.18 11.56,119.18 11.69,119.05 11.69,117.91 11.56,117.78 ; 1 cut-out
20V_VCCPD_VBUS on BOTTOM: 9.63,124.49 9.55,124.56 9.55,124.97 9.63,125.05 10.14,125.05 10.54,125.45 12.14,125.45 12.27,125.32 12.27,124.61 12.14,124.49 ; 2 cut-outs
20V_VCCPD_VBUS on L3: 42.07,129.39 42.07,126.06 41.15,125.15 37.75,125.15 35.84,127.05 32.11,127.05 29.14,124.08 29.14,114.89 28.5,114.25 28.5,112.65 26.06,110.21 24.16,110.21 23.9,110.47 23.9,111.28 25.23,112.6 25.23,118.64 21.09,122.78 19.31,122.78 18.47,121.95 17.76,121.95 16.21,120.4 14.71,120.4 13.2,118.89 12.46,118.89 11.36,117.78 9.99,117.78 9.32,118.44 9.32,119.76 8.13,120.96 7.57,120.96 6.45,122.07 6.45,122.56 6.58,122.68 7.04,122.68 7.32,122.96 7.32,124.41 7.01,124.72 6.61,124.72 6.48,124.84 6.48,125.48 7.39,126.39 8.08,126.39 8.59,126.9 8.59,127.28 10.93,129.62 26.39,129.62 28.63,131.85 39.6,131.85
+3VALW_EC on TOP: 58.3,27.66 57.89,28.07 57.89,29.03 58.04,29.19 74.86,29.19 75.06,28.98 75.06,27.89 74.83,27.66 ; 2 cut-outs
+3VALW_EC on TOP: 33.96,74.73 33.71,74.98 33.71,75.29 33.91,75.49 35.26,75.49 36.27,76.51 37.01,76.51 37.24,76.28 37.75,76.28 37.9,76.13 37.9,75.74 37.67,75.52 36.43,75.52 35.64,74.73
+3VALW_EC on TOP: 34.29,110.42 34.04,110.67 34.04,113.72 33.89,113.87 33.68,113.87 33.51,114.05 33.51,114.66 33.58,114.73 34.93,114.73 35.06,114.61 35.06,114.1 34.67,113.72 34.67,110.54 34.55,110.42
+3VALW_EC on TOP: 20.4,68.89 20.09,69.19 19.21,69.19 19.05,69.34 19.05,70.13 19.28,70.36 20.55,70.36 20.81,70.61 20.81,71.02 20.98,71.2 22.81,71.2 22.96,71.05 22.96,70.64 22.81,70.49 21.49,70.49 21.19,70.18 21.19,69.11 20.96,68.89
+5V_PVDD on TOP: 31.91,11.86 31.65,12.12 30.79,12.12 30.76,12.14 30.76,12.27 30.84,12.35 31.7,12.35 31.88,12.52 32.69,12.52 33.45,13.29 33.45,14.07 33.33,14.2 32.18,14.2 32.11,14.28 32.11,14.58 31.78,14.91 31.32,14.91 30.81,15.42 30.28,15.42 30.23,15.47 30.23,15.62 30.28,15.67 31.65,15.67 32.39,16.41 32.39,18.04 32.67,18.31 33.61,18.31 33.84,18.09 33.84,15.06 34.27,14.63 34.27,12.5 34.14,12.37 33.68,12.37 33.18,11.86 ; 2 cut-outs
GND on TOP: 151.9,79.94 151.39,80.44 151.39,81.71 150.57,82.53 150.57,83.19 150.75,83.36 153.9,83.36 154,83.26 154,82.09 154.66,81.43 156.26,81.43 156.77,81.94 158.09,81.94 158.25,81.79 158.25,81.51 157.74,81 156.87,81 156.71,80.84 156.71,80.18 156.47,79.94 ; 5 cut-outs
GND on TOP: 133.28,126.72 133.05,126.95 131.96,126.95 130.65,128.26 130.44,128.26 129.62,129.08 129.62,129.47 130.13,129.97 130.53,129.97 131.55,128.96 131.7,128.96 132.34,128.32 132.72,128.32 133.23,128.83 133.89,128.83 134.14,128.58 134.37,128.58 134.67,128.88 134.95,128.88 135.51,128.32 135.77,128.32 137.29,129.85 137.29,129.97 136.15,131.12 136.15,131.37 135.13,132.39 134.88,132.39 134.75,132.51 134.75,132.89 134.88,133.02 135.77,133.02 135.89,133.15 136.02,133.15 136.27,132.89 136.27,132.64 136.15,132.51 136.15,132.26 136.91,131.5 137.16,131.5 137.29,131.62 137.42,131.62 138.69,130.35 138.69,130.1 136.78,128.2 136.78,127.79 136.93,127.64 136.93,127.53 136.63,127.23 136.02,127.23 135.61,126.82 135.33,126.82 134.29,127.86 134.06,127.86 133.81,127.61 133.81,126.95 133.58,126.72 ; 12 cut-outs
GND on TOP: 41.66,104.95 41.53,105.08 41.53,106.94 41.68,107.09 42.01,107.09 42.93,108 43.31,108 43.41,107.9 43.41,106.71 43.34,106.63 42.24,106.63 42.12,106.5 42.12,104.98 42.09,104.95 ; 2 cut-outs
GND on TOP: 79.51,128.88 79.28,129.11 79.28,132.18 79.07,132.39 74.65,132.39 74.53,132.51 74.53,135 74.88,135.36 79.28,135.36 80.09,134.55 80.78,134.55 81.71,135.48 86.12,135.48 86.55,135.05 86.55,132.63 86.17,132.25 81.68,132.25 81.13,131.7 81.13,129.08 80.93,128.88 ; 3 cut-outs
GND on TOP: 71.45,38.36 71.12,38.69 71.12,40.31 71.25,40.44 72.57,40.44 72.67,40.34 72.67,39.02 72.01,38.36 ; 3 cut-outs
GND on TOP: 75.29,114.73 75.09,114.94 75.09,118.21 71.25,122.05 71.25,132.13 71,132.39 69.22,132.39 69.18,132.42 65.78,132.42 65.05,133.15 65.05,136.78 65.23,136.96 65.76,136.96 65.87,136.86 65.87,135.56 66.25,135.18 71.78,135.18 72.14,135.54 72.14,136.81 71.99,136.96 71.99,137.97 72.14,138.13 72.14,139.45 71.96,139.63 71.96,141.23 72.09,141.35 72.77,141.35 72.88,141.25 72.88,140.87 72.98,140.77 73.54,140.77 73.82,140.49 73.82,139.96 73.99,139.78 73.99,138.02 73.64,137.67 73.64,137.26 73.37,137 73.37,135.64 73.97,135.04 73.97,133.71 73.99,133.68 73.99,132.61 73.16,131.78 73.16,123.24 73.54,122.86 77.22,122.86 77.47,122.61 77.47,114.86 77.35,114.73 ; 26 cut-outs
GND on TOP: 88.34,92.53 88.17,92.71 88.17,99.49 88.24,99.57 90.63,99.57 90.81,99.39 90.81,92.69 90.66,92.53 ; 10 cut-outs
GND on TOP: 93.35,140.77 93.2,140.92 93.2,144.58 93.35,144.73 93.91,144.73 94.24,144.4 94.24,143.23 94.26,143.21 94.26,140.9 94.14,140.77 ; 4 cut-outs
GND on TOP: 108.38,117.37 108.28,117.48 108.28,119.25 108.41,119.38 108.66,119.38 108.97,119.69 108.97,120.58 109.22,120.83 109.22,121.21 109.78,121.77 109.78,122.25 109.86,122.33 110.26,122.33 110.32,122.28 110.32,121.95 109.73,121.36 109.73,118.8 110.49,118.04 110.49,117.48 110.39,117.37 ; 1 cut-out
GND on TOP: 112.09,30.35 112.08,30.37 111.01,30.37 110.82,30.56 110.82,31.29 111.65,32.12 111.65,33.52 111.84,33.71 113.41,33.71 114.18,32.95 114.18,30.91 113.62,30.35 ; 2 cut-outs
GND on TOP: 176.15,34.42 174.93,35.64 174.93,37.01 175.16,37.24 176.79,37.24 176.84,37.19 176.84,36.35 176.71,36.22 176.71,35.97 176.96,35.71 178.13,35.71 178.21,35.64 178.21,35.26 178.16,35.21 176.79,35.21 176.58,35 176.58,34.49 176.51,34.42 ; 3 cut-outs
GND on TOP: 89.2,30.65 89.02,30.82 89.02,31.18 90.38,32.54 90.38,34.67 90.55,34.85 91.01,34.85 91.06,34.8 91.06,30.94 90.77,30.65 ; 1 cut-out
GND on TOP: 145.04,78.16 144.99,78.21 144.99,78.67 144.73,78.92 144.53,78.92 144.35,79.1 144.35,80.8 144.2,80.95 142.37,80.95 141.74,80.32 140.44,80.32 140.36,80.24 140.36,79.6 140.34,79.58 139.86,79.58 139.78,79.66 139.78,80.19 139.65,80.32 137.75,80.32 137.24,80.82 137.24,82.37 137.29,82.42 137.93,82.42 138.71,81.64 140.54,81.64 141.05,82.14 141.35,82.14 141.68,82.48 141.68,83.01 141.81,83.14 142.7,83.14 143.31,82.53 144.1,82.53 145.04,81.59 145.04,81.08 145.29,80.82 146.69,80.82 147.07,80.44 147.07,79.81 146.94,79.68 146.43,79.68 146.31,79.55 146.31,78.28 146.18,78.16 ; 10 cut-outs
GND on TOP: 86.01,151 85.86,151.16 85.09,151.16 84.99,151.26 84.99,152.3 85.07,152.38 85.52,152.38 85.75,152.15 88.14,152.15 88.32,151.97 88.32,151.74 87.58,151 ; 1 cut-out
GND on TOP: 37.77,105.79 37.47,106.1 37.47,108.33 37.98,108.84 39.42,108.84 39.5,108.76 39.5,108.26 39.37,108.13 38.61,108.13 38.36,107.88 38.36,105.84 38.31,105.79 ; 3 cut-outs
GND on TOP: 88.52,137.09 88.4,137.21 88.4,137.97 90.94,140.51 91.19,140.51 91.32,140.39 91.32,138.1 91.19,137.97 90.55,137.97 90.43,137.85 90.43,137.21 90.3,137.09
GND on TOP: 64.73,94.68 63.25,96.17 63.25,103.18 63.3,103.23 63.78,103.23 63.99,103.02 63.99,102.49 65.66,100.81 65.66,94.77 65.57,94.68 ; 7 cut-outs
GND on TOP: 168.3,129.57 167.64,130.23 162.56,130.23 161.93,130.86 161.93,136.58 162.06,136.7 167.9,136.7 168.28,137.09 168.41,136.96 168.41,136.2 168.53,136.07 168.53,134.62 168.56,134.6 168.56,129.69 168.43,129.57 ; 11 cut-outs
GND on TOP: 59.34,35.87 59.03,36.17 57.86,36.17 57.66,36.37 57.66,38.53 57.99,38.86 60.18,38.86 60.3,38.74 60.3,35.92 60.25,35.87 ; 4 cut-outs
GND on TOP: 131.96,51.23 131.83,51.36 131.83,51.87 131.7,52 131.32,52 131.19,52.12 131.19,52.76 131.32,52.88 134.88,52.88 135,52.76 135,52.38 135.13,52.25 138.41,52.25 138.61,52.45 138.61,52.83 138.79,53.01 139.14,53.01 139.25,52.91 139.25,52.43 139.42,52.25 142.24,52.25 142.37,52.12 142.37,51.49 142.12,51.23 ; 3 cut-outs
GND on TOP: 77.52,146.94 77.45,147.02 77.45,151.31 77.22,151.54 77.22,152.1 77.37,152.25 78.26,152.25 78.36,152.15 78.36,151.44 78.51,151.28 80.88,151.28 81.28,150.88 81.28,147.96 81.44,147.8 81.63,147.8 81.66,147.77 81.66,146.99 81.63,146.95 81.47,146.95 81.46,146.94 ; 14 cut-outs
GND on TOP: 57.36,132.56 56.52,133.4 56.52,134.42 56.77,134.67 57.28,134.67 57.53,134.42 57.53,133.78 57.66,133.66 59.19,133.66 59.31,133.78 59.31,134.42 59.06,134.67 59.06,135.38 58.68,135.76 58.68,137.26 58.85,137.44 60.91,137.44 61.17,137.19 61.17,135.92 60.58,135.33 60.58,132.84 60.3,132.56 ; 4 cut-outs
GND on TOP: 157.38,104.34 157.18,104.55 157.18,106.33 157.31,106.45 158.45,106.45 158.63,106.27 158.63,105.39 157.58,104.34
GND on TOP: 201.56,46.94 201.3,47.2 201.3,49.48 201.43,49.61 201.91,49.61 201.98,49.69 201.98,50.06 202.36,50.45 202.6,50.45 202.7,50.55 202.7,50.75 202.95,51.01 204.35,51.01 204.61,50.75 204.61,50.34 204.93,50.01 205.31,50.01 205.57,49.76 205.57,49.25 205.29,48.97 205.24,48.97 205.24,47.07 205.11,46.94 204.61,46.94 204.35,47.2 203.84,47.2 203.72,47.32 202.95,47.32 202.83,47.2 202.07,47.2 201.81,46.94 ; 7 cut-outs
GND on TOP: 151.34,107.52 150.24,108.61 150.24,108.87 150.63,109.25 150.63,109.5 150.4,109.73 149.94,109.73 149.61,110.06 149.61,113.18 149.1,113.69 149.1,115.09 149.28,115.27 150.35,115.27 150.63,114.99 150.63,110.77 151.82,109.58 151.82,107.85 151.49,107.52 ; 4 cut-outs
GND on TOP: 106.58,125.25 106.48,125.35 106.48,127 106.18,127.31 106.18,130.56 106.05,130.68 103.99,130.68 103.41,131.27 103.41,133.94 103.76,134.29 108.21,134.29 108.33,134.16 108.33,131.24 107.09,130 107.09,127.41 107.45,127.05 107.45,126.06 107.06,125.68 107.06,125.32 106.99,125.25 ; 1 cut-out
GND on TOP: 32.48,104.76 32.44,104.8 32.44,105.26 32.31,105.39 30.36,105.39 30.28,105.46 29.31,105.46 29.24,105.54 29.24,106.53 29.44,106.73 32.13,106.73 32.39,106.48 32.39,105.82 32.95,105.26 32.95,104.83 32.88,104.76 ; 4 cut-outs
GND on TOP: 133.61,33.71 133.23,34.09 133.23,37.39 133.35,37.52 134.04,37.52 134.12,37.44 134.12,35.23 134.37,34.98 134.57,34.98 134.72,34.82 134.72,33.94 134.5,33.71 ; 3 cut-outs
GND on TOP: 147.37,82.07 147.27,82.17 147.27,82.75 147.15,82.88 145.6,82.88 144.91,83.57 144.91,88.83 145.16,89.08 146.28,89.08 146.28,90.04 146.36,90.12 148.06,90.12 149.1,89.08 150.37,89.08 150.63,88.83 150.63,85.12 150.48,84.98 149.64,84.98 149.49,84.82 149.49,83.04 149.33,82.88 148.36,82.88 148.14,82.65 148.14,82.25 147.96,82.07 ; 3 cut-outs
GND on TOP: 48.54,108.89 48.36,109.07 47.88,109.07 47.53,109.42 45.34,109.42 45.16,109.6 45.16,110.36 45.6,110.8 48.16,110.8 48.36,110.59 48.36,109.63 48.57,109.42 49.05,109.42 49.13,109.35 49.13,108.99 49.03,108.89 ; 2 cut-outs
GND on TOP: 46.19,131.13 46.13,131.19 46.13,132.23 46,132.36 45.37,132.36 45.32,132.41 45.32,132.56 45.34,132.59 45.98,132.59 46.13,132.74 46.13,134.09 45.85,134.37 45.82,134.37 45.93,134.47 47.15,134.47 47.3,134.32 47.04,134.06 47.04,131.18 46.99,131.13
GND on TOP: 133.86,120.98 133.23,121.62 133.23,123.24 132.9,123.57 132.9,123.72 133.76,124.59 133.84,124.59 134.17,124.26 134.17,124.23 133.89,123.95 133.89,123.72 134.19,123.42 134.19,123.22 133.76,122.78 133.76,122.25 134.42,121.59 134.42,121.24 134.17,120.98 ; 1 cut-out
GND on TOP: 49.99,126.59 49.84,126.75 49.84,130.2 52.28,132.64 56.34,132.64 57.43,131.55 57.43,130.76 57.28,130.61 54.66,130.61 54.46,130.4 53.8,130.4 53.65,130.25 53.65,129.54 53.47,129.36 52.91,129.36 52.71,129.16 52.02,129.16 51.79,129.39 51.11,129.39 50.98,129.26 50.98,126.85 50.73,126.59 ; 7 cut-outs
GND on TOP: 216.33,40.82 216.26,40.9 216.26,41.35 216.74,41.84 216.87,41.84 217.43,42.39 218.24,42.39 218.47,42.17 219.26,42.17 219.33,42.09 219.33,40.9 219.26,40.82 ; 2 cut-outs
GND on TOP: 172.85,46.46 172.62,46.69 172.62,48.82 172.67,48.87 173.74,48.87 173.92,49.05 173.92,50.67 173.79,50.8 172.98,50.8 172.85,50.93 172.85,51.36 172.9,51.41 175.11,51.41 175.19,51.33 175.19,50.93 174.58,50.32 174.58,49.91 174.4,49.73 174.4,48.41 173.54,47.55 173.54,46.71 173.28,46.46 ; 2 cut-outs
GND on TOP: 126.75,128.45 126.37,128.83 126.37,129.11 126.95,129.69 126.95,130.15 127.23,130.43 127.23,131.01 126.93,131.32 126.93,131.42 127.1,131.6 127.16,131.6 127.77,130.99 127.77,130.57 127.38,130.19 127.38,129.59 127.77,129.21 127.77,128.96 127.26,128.45
GND on TOP: 61.9,114.56 61.6,114.86 61.6,118.06 61.36,118.3 61.36,118.68 60.77,119.27 60.21,119.27 59.77,119.71 59.77,122.91 59.97,123.12 61.78,123.12 61.95,123.29 62,123.29 62.06,123.34 62.06,127.64 62.28,127.86 63.27,127.86 63.5,127.64 63.5,125.53 63.38,125.4 63.38,114.73 63.2,114.56 ; 19 cut-outs
GND on TOP: 98.39,114.87 97.08,116.18 97.08,118.67 96.88,118.87 96.88,119.71 96.9,119.74 96.9,125.22 96.57,125.55 96.57,128.88 96.9,129.21 97.29,129.21 97.54,128.96 97.54,126.26 98.17,125.63 98.17,119.79 98.77,119.19 98.77,114.87 ; 12 cut-outs
GND on TOP: 87.07,146.86 86.95,146.99 86.95,148.13 87.05,148.24 88.29,148.24 88.42,148.11 88.42,147.04 88.24,146.86 ; 1 cut-out
GND on TOP: 128.44,107.45 128.33,107.56 128.33,107.77 128.42,107.86 128.42,109.28 127.36,110.34 127.36,111.25 126.52,112.09 126.52,112.37 126.77,112.62 127.18,112.62 127.77,112.04 127.77,111.63 128.32,111.08 128.73,111.08 128.93,110.87 128.93,110.52 128.65,110.24 128.65,109.98 128.93,109.7 128.93,109.42 128.92,109.42 128.92,107.64 128.74,107.45 ; 1 cut-out
GND on TOP: 31.04,133.48 30.99,133.53 30.99,134.16 30.76,134.39 30.76,134.49 30.97,134.7 34.34,134.7 34.5,134.55 34.5,134.37 33.61,133.48 ; 3 cut-outs
GND on TOP: 193.81,33.58 193.68,33.71 193.68,34.09 193.81,34.22 197.36,34.22 197.49,34.09 197.49,33.71 197.36,33.58 ; 1 cut-out
GND on TOP: 151.07,97.84 150.95,97.97 150.95,98.55 150.87,98.63 150.86,98.63 150.63,98.87 150.63,102.29 150.88,102.54 152.91,102.54 153.04,102.67 153.04,106.33 153.11,106.4 153.95,106.4 154.18,106.17 154.18,97.97 154.05,97.84 ; 5 cut-outs
GND on TOP: 129.67,130.99 129.16,131.5 129.16,132.13 128.91,132.39 128.64,132.39 128.38,132.13 128.27,132.13 128.02,132.39 128.02,132.51 128.78,133.28 129.04,133.28 129.42,132.89 130.18,132.89 130.43,133.15 130.56,133.15 131.19,132.51 131.19,132.26 129.92,130.99 ; 2 cut-outs
GND on TOP: 158.47,87.45 158.37,87.56 158.37,87.91 158.47,88.01 160.3,88.01 160.35,87.96 160.35,87.53 160.28,87.45
GND on TOP: 89.03,114.86 88.52,115.37 88.52,118.42 88.4,118.54 86.87,118.54 86.74,118.67 86.74,126.42 86.87,126.54 87.51,126.54 87.63,126.67 87.63,128.32 87.86,128.55 88.14,128.55 88.73,129.13 88.73,130.2 88.47,130.46 88.09,130.46 87.84,130.71 87.84,133.12 88.04,133.33 89.49,133.33 89.67,133.15 89.67,128.96 89.41,128.7 89.41,124.64 89.67,124.39 89.67,121.85 90.3,121.21 90.3,115.11 90.05,114.86 ; 13 cut-outs
GND on TOP: 95.63,90.88 95.56,90.96 95.56,91.21 95.42,91.35 93.97,91.35 93.73,91.59 93.73,91.95 94.34,92.56 94.34,99.47 94.39,99.52 95.94,99.52 95.96,99.49 96.7,99.49 96.88,99.32 96.88,91.87 97.04,91.71 97.32,91.71 97.69,91.34 97.69,90.98 97.59,90.88 ; 14 cut-outs
GND on TOP: 204.78,53.39 204.65,53.52 204.65,54.94 204.8,55.09 206.45,55.09 206.68,54.87 206.68,53.57 206.58,53.47 206.23,53.47 206.1,53.6 206.1,53.8 206,53.9 205.62,53.9 205.49,53.77 205.49,53.49 205.39,53.39 ; 2 cut-outs
GND on TOP: 70.11,114.61 69.98,114.73 69.98,117.15 70.11,117.27 71.12,117.27 71.25,117.15 71.25,115.62 71.5,115.37 72.27,115.37 72.39,115.24 72.39,114.73 72.27,114.61 ; 2 cut-outs
GND on TOP: 157.31,65.51 157.15,65.66 157.15,66.42 156.96,66.61 156.05,66.61 155.88,66.78 155.88,67.57 156.06,67.74 157.36,67.74 157.86,67.24 157.86,66.07 157.89,66.04 157.89,65.66 157.74,65.51
GND on TOP: 141.61,98.6 141.1,99.11 141.1,106.35 141.48,106.73 143.39,106.73 143.64,106.48 143.64,102.27 143.82,102.09 143.82,98.99 143.43,98.6 ; 4 cut-outs
GND on TOP: outline of 589 points within 1.41,0.76 226.24,156.24 ; 32 cut-outs
GND on TOP: 183.26,33.17 183.14,33.3 183.14,33.63 183.19,33.68 186.64,33.68 186.72,33.76 187.43,33.76 187.51,33.68 188.22,33.68 188.29,33.61 188.29,33.2 188.27,33.17
GND on TOP: 106.38,40.31 105.95,40.74 105.95,41.53 106.68,42.27 110.06,42.27 110.16,42.17 110.16,41.1 109.38,40.31 ; 3 cut-outs
GND on TOP: 133.35,129.34 132.85,129.85 132.85,129.97 133.48,130.61 133.48,130.86 133.1,131.24 132.85,131.24 131.7,132.39 131.7,132.77 132.08,133.15 132.34,133.15 132.59,132.89 132.97,132.89 133.48,133.4 133.61,133.4 134.24,132.77 134.24,132.51 133.61,131.88 133.61,131.62 133.99,131.24 134.24,131.24 134.75,130.74 134.75,130.48 133.61,129.34 ; 1 cut-out
GND on TOP: 154.18,112.7 153.29,113.59 153.29,115.11 153.42,115.24 166.88,115.24 167.52,114.61 167.52,113.97 166.25,112.7 ; 24 cut-outs
GND on TOP: 154.46,36.65 154.36,36.76 154.36,37.52 154.46,37.62 155.58,37.62 155.71,37.75 155.71,40.06 156.09,40.44 159.13,40.44 159.39,40.18 159.39,39.68 159.26,39.55 156.72,39.55 156.47,39.3 156.47,36.7 156.42,36.65 ; 5 cut-outs
GND on TOP: 76.91,31.22 76.36,31.78 76.36,32.28 76.46,32.39 79.07,32.39 79.28,32.59 79.89,32.59 80.14,32.34 80.14,31.4 79.96,31.22 ; 3 cut-outs
GND on TOP: 78.87,138.46 78.54,138.79 76.71,138.79 76.15,139.35 76.15,141.66 76.67,142.18 77.97,142.18 78.21,141.94 78.21,139.73 78.57,139.37 79.02,139.37 79.53,138.86 79.53,138.53 79.45,138.46 ; 4 cut-outs
GND on TOP: 55.6,123.55 55.27,123.88 55.27,124.87 55.43,125.02 57.53,125.02 57.74,124.82 57.74,123.88 57.41,123.55 ; 1 cut-out
GND on TOP: 24.64,120.58 24.41,120.8 24.41,123.19 24.54,123.32 26.04,123.32 26.17,123.19 26.17,120.65 26.09,120.58
GND on TOP: 104.75,114.91 104.73,114.94 104.73,115.9 104.93,116.1 104.93,116.92 105.08,117.07 105.84,117.07 106.15,116.77 106.15,115.04 106.02,114.91 ; 1 cut-out
GND on TOP: 78.46,99.09 78.67,98.88 78.67,98.25 78.85,98.07 82.2,98.07 82.35,97.92 82.35,97.03 82.63,96.75 84.05,96.75 84.16,96.64 84.16,92.81 83.56,92.21 83.56,91.2 84.05,90.7 85.6,90.7 85.68,90.63 85.68,89.71 85.52,89.56 76.1,89.56 75.67,89.99 75.67,90.25 75.16,90.76 75.16,91.59 75.39,91.82 82.14,91.82 82.46,92.13 82.46,95.98 82.23,96.21 74.32,96.21 74.09,96.44 74.09,98.91 74.27,99.09 ; 23 cut-outs
GND on TOP: 20.5,0.92 20.45,0.97 20.45,1.86 20.09,2.21 18.42,2.21 18.37,2.26 18.37,2.62 18.42,2.67 19.79,2.67 19.84,2.62 20.83,2.62 21.06,2.39 21.06,1.02 20.96,0.92
GND on TOP: 95.68,32.39 95.56,32.51 95.56,33.3 95.94,33.68 96.62,33.68 96.9,33.96 96.9,37.42 97.06,37.57 97.39,37.57 97.54,37.42 97.54,33.45 97.11,33.02 96.55,33.02 96.22,32.69 96.22,32.51 96.09,32.39
GND on BOTTOM: 16.84,121.11 16.69,121.26 16.69,122.33 16.77,122.4 18.39,122.4 18.55,122.56 18.82,122.56 18.93,122.45 18.93,121.44 18.6,121.11
GND on BOTTOM: 152.73,78.21 152.48,78.46 152.48,80.39 151.56,81.31 151.56,82.2 151.08,82.68 147.12,82.68 147.07,82.73 146.21,82.73 145.93,83.01 145.93,84.86 145.77,85.02 144.94,85.02 144.66,85.29 144.66,88.44 144.91,88.7 146.05,88.7 146.43,89.08 146.43,89.43 146.59,89.59 148.52,89.59 148.85,89.26 148.85,88.95 148.57,88.67 148.57,88.14 148.82,87.89 149.18,87.89 149.51,87.56 150.52,87.56 150.63,87.45 150.63,83.64 150.93,83.34 153.95,83.34 154,83.29 154,80.19 155.15,79.05 155.15,78.41 154.94,78.21 ; 2 cut-outs
GND on BOTTOM: 97.11,134.09 96.95,134.24 96.95,134.44 97.13,134.62 97.13,136.17 97.11,136.2 96.45,136.2 95.86,136.78 95.86,138.46 95.96,138.56 96.47,138.56 96.78,138.86 96.78,139.83 97.18,140.23 98.4,140.23 98.5,140.13 98.5,139.45 98.22,139.17 98.22,136.58 98.15,136.5 98.15,134.75 97.49,134.09 ; 2 cut-outs
GND on BOTTOM: 21.54,103.43 21.43,103.54 21.43,103.67 20.88,104.22 20.88,105.74 20.75,105.87 19.87,105.87 19.76,105.97 19.76,107.29 19.87,107.39 20.48,107.39 20.7,107.62 21.54,107.62 21.77,107.85 21.77,108.69 21.9,108.81 22.66,108.81 22.74,108.74 22.74,108.33 22.56,108.15 22.56,107.47 22.61,107.42 23.09,107.42 23.29,107.21 23.29,103.71 23.02,103.43 ; 11 cut-outs
GND on BOTTOM: 81.84,135.87 81.84,137.03 83.26,137.03 83.26,135.87
GND on BOTTOM: 182.83,60.76 180.11,63.48 179.23,63.48 179.17,63.53 179.17,64.39 179.38,64.59 181,64.59 181.21,64.8 181.21,67.77 180.98,68 179.45,68 179.35,68.1 179.35,69.32 179.4,69.37 181.28,69.37 181.99,70.08 181.99,70.89 182.73,70.89 183.06,70.56 183.26,70.76 185.07,69.99 186.92,69.33 187.97,68.8 188.81,67.97 189.43,67.43 190.24,67.24 191.06,67.24 191.06,67.24 191.06,66.68 190.53,66.14 190.53,61.57 190,61.04 183.21,61.04 182.93,60.76
GND on BOTTOM: 45.43,30.77 44.99,31.22 44.99,31.75 45.18,31.94 51.58,31.94 52.52,32.88 54.6,32.88 55.12,32.36 55.12,31.98 54.64,31.5 52.68,31.5 51.96,30.77 ; 2 cut-outs
GND on BOTTOM: 163.27,78.92 162.84,79.35 162.16,79.35 162.06,79.45 162.06,83.52 161.78,83.8 161.78,84.99 161.84,85.05 164.15,85.05 164.38,84.82 164.38,82.01 164.21,81.84 164.21,81.08 164.39,80.9 164.39,79.76 164.6,79.55 164.6,79.05 164.47,78.92 ; 9 cut-outs
GND on BOTTOM: 159.29,33.58 158.78,34.09 155.98,34.09 154.71,35.36 153.24,35.36 153.17,35.43 153.17,38.41 151.64,39.93 147.09,39.93 147.08,39.94 146.14,39.94 145.55,40.54 144.83,40.54 144.71,40.67 144.71,41.12 144.76,41.17 153.7,41.17 154.32,40.55 154.32,40.54 154.38,40.48 154.38,37.77 154.92,37.24 161.75,37.24 162.49,37.97 162.49,39.4 162.51,39.42 165.89,39.42 166.04,39.27 166.04,34.29 165.84,34.09 162.59,34.09 162.54,34.04 162.54,33.71 162.41,33.58
GND on BOTTOM: 21.57,82.91 20.91,83.57 20.91,83.95 22.13,85.17 23.29,85.17 23.47,84.99 23.47,83.11 23.27,82.91
GND on BOTTOM: 139.14,98.78 138.86,99.06 138.86,101.02 141.15,103.3 141.15,104.55 141.28,104.67 142.32,104.67 142.62,104.98 142.62,107.37 142.75,107.49 143.26,107.49 143.64,107.11 143.64,106.3 143.59,106.25 143.59,98.93 143.44,98.78 ; 1 cut-out
GND on BOTTOM: 61.5,118.14 61.34,118.29 61.34,118.67 60.58,119.43 60.58,120.07 62.36,121.85 62.36,127.81 62.49,127.94 62.87,127.94 63.12,127.69 63.12,123.5 63.88,122.73 65.15,122.73 65.41,122.48 65.41,119.94 63.6,118.14
GND on BOTTOM: 76.3,37.52 76.23,37.59 76.23,38.76 75.95,39.04 72.37,39.04 72.19,38.86 72.19,38.51 72.06,38.38 71.58,38.38 71.39,38.57 71.39,39.18 71.38,39.19 71.38,39.5 70.84,40.03 70.44,40.03 70.28,40.18 70.28,40.82 69.68,41.43 69.68,41.68 69.83,41.84 70.18,41.84 70.89,41.12 70.89,40.59 71.61,39.88 75.9,39.88 76.18,40.16 76.18,41.53 76.53,41.89 77.07,41.89 77.63,41.33 81.46,41.33 81.54,41.25 81.54,38.51 81.49,38.46 79,38.46 78.06,37.52 ; 1 cut-out
GND on BOTTOM: 85.19,88.27 84.69,88.77 84.69,89.43 84.53,89.59 77.07,89.59 76.79,89.31 76.79,88.75 76.69,88.65 76.28,88.65 75.95,88.98 75.95,89.64 75.87,89.71 75.06,89.71 73.79,90.98 73.79,92.3 73.69,92.41 73.69,93.37 73.16,93.91 71.71,93.91 71.53,93.73 68.84,93.73 68.28,94.29 68.28,94.54 74.93,94.54 75.06,94.41 75.06,92.76 75.31,92.51 84.71,92.51 85.93,91.29 85.93,89.21 85.6,88.88 85.6,88.34 85.52,88.27
GND on BOTTOM: 158.32,82.73 158.27,82.78 158.27,84.68 158.37,84.79 158.78,84.79 159.67,83.9 159.67,82.88 159.52,82.73 ; 2 cut-outs
GND on BOTTOM: 85.86,119.94 85.86,122.48 87.63,124.26 87.63,132.21 86.73,133.11 85.83,133.11 85.54,133.4 81.92,133.4 81.79,133.53 81.79,134.55 81.92,134.67 82.43,134.67 82.55,134.8 82.55,135.43 82.68,135.56 87.63,135.56 87.89,135.31 87.89,134.04 88.42,133.5 88.62,133.5 89.44,132.69 89.44,130.58 89.33,130.48 87.81,130.48 87.68,130.35 87.68,128.65 87.81,128.53 89.21,128.53 89.41,128.32 89.41,120.83 88.52,119.94 ; 2 cut-outs
GND on BOTTOM: outline of 615 points within 1.41,0.76 226.24,156.24 ; 28 cut-outs
GND on BOTTOM: 63.27,134.29 63.2,134.37 63.2,135.13 63.63,135.56 64.52,135.56 64.52,135.26 63.83,135.26 63.71,135.13 63.71,134.37 63.63,134.29
GND on BOTTOM: 16.64,55.35 16.23,55.75 16.23,56.57 16.44,56.77 18.24,56.77 18.84,56.17 20.64,56.17 20.81,56.01 20.81,55.5 20.65,55.35 ; 2 cut-outs
GND on BOTTOM: 105.74,127.53 105.57,127.71 105.57,128.25 106.05,128.73 106.05,130.66 106,130.71 104.12,130.71 103.66,131.17 103.66,133.91 103.53,134.04 101.98,134.04 101.86,134.16 101.86,134.8 104.78,134.8 105.16,134.42 108.21,134.42 108.46,134.67 108.46,135.54 110.09,137.16 110.39,137.16 110.67,137.44 110.67,137.97 110.16,138.48 110.16,140.79 110.34,140.97 111.38,140.97 114.39,137.96 114.39,133.97 111.86,131.45 108.54,131.45 107.09,130 107.09,128.09 106.53,127.53 ; 5 cut-outs
GND on BOTTOM: 41.96,79.53 41.89,79.6 41.89,80.54 41.99,80.65 42.75,80.65 42.93,80.47 43.51,80.47 43.67,80.62 43.67,81.21 43.79,81.33 44.38,81.33 44.53,81.48 44.53,83.75 44.4,83.87 44.4,83.9 44.33,83.97 44.07,83.97 43.97,84.08 43.97,84.56 44.1,84.68 44.45,84.68 44.47,84.7 45.81,84.7 46.33,85.22 46.59,85.22 46.69,85.32 46.69,85.85 46.79,85.95 46.94,85.95 47.09,86.11 47.09,86.49 47.25,86.64 47.81,86.64 47.91,86.54 47.91,86.06 48.09,85.88 48.09,82.86 48.24,82.7 48.69,82.7 48.77,82.63 48.77,81.81 48.31,81.36 46.26,81.36 45.88,81.74 45.32,81.74 44.97,81.4 44.97,81.38 44.92,81.33 44.92,80.74 43.72,79.53 ; 11 cut-outs
GND on BOTTOM: 10.86,123.43 10.26,124.03 10.26,124.16 10.42,124.31 10.8,124.31 10.93,124.18 11.41,124.18 11.48,124.11 11.48,123.57 11.34,123.43
GND on BOTTOM: 125.62,117.77 122.53,120.85 122.28,120.85 121.36,121.77 121.36,122.53 117.17,126.72 117.17,127.26 117.39,127.47 117.57,127.47 117.86,127.18 118.24,127.18 118.49,127.43 118.88,127.43 127.87,118.44 128.04,118.44 128.15,118.54 128.27,118.54 128.5,118.31 128.5,118.14 128.13,117.77 ; 9 cut-outs
GND on BOTTOM: 51.77,40.36 51.62,40.51 51.62,41.53 51.95,41.86 53.95,41.86 54.51,41.3 54.84,41.3 54.94,41.2 54.94,40.41 54.89,40.36 ; 2 cut-outs
GND on BOTTOM: 97.26,124.39 97.01,124.64 97.01,125.3 96.68,125.63 96.68,128.91 96.93,129.16 97.41,129.16 97.51,129.06 97.51,126.01 97.95,125.58 97.95,124.51 97.82,124.39
GND on BOTTOM: 63.88,95.18 63.25,95.81 63.25,103.13 63.38,103.25 65.1,103.25 65.54,102.82 65.54,99.87 65.28,99.62 65.28,95.3 65.15,95.18 ; 3 cut-outs
GND on BOTTOM: 23.47,42.95 23.18,43.24 23.18,43.63 23.27,43.71 23.6,43.71 23.85,43.97 23.85,45.01 23.57,45.29 23.21,45.29 23.18,45.31 23.18,45.63 23.24,45.7 23.65,45.7 23.83,45.87 23.83,46.99 23.57,47.25 23.33,47.25 23.18,47.4 23.18,48.17 23.7,48.69 26.47,48.69 26.6,48.57 26.6,43.18 26.37,42.95
GND on BOTTOM: 94.59,39.12 94.44,39.27 94.44,39.9 94.29,40.06 92.03,40.06 91.85,39.88 91.49,39.88 91.39,39.98 91.39,41.23 91.57,41.4 95.18,41.4 95.43,41.15 95.43,39.19 95.35,39.12 ; 3 cut-outs
GND on BOTTOM: 214.02,43.08 213.92,43.18 213.92,43.56 214.05,43.69 215.83,43.69 215.88,43.64 215.88,43.21 215.75,43.08
GND on BOTTOM: 64.32,36.27 64.24,36.35 64.24,39.68 63.6,40.31 63.6,41.73 63.76,41.89 64.47,41.89 64.7,41.66 64.7,40.23 65.1,39.83 65.1,36.35 65.03,36.27 ; 2 cut-outs
GND on BOTTOM: 165,111.25 164.9,111.35 164.9,112.07 164.67,112.29 163.63,112.29 163.4,112.07 162.16,112.07 162.08,112.14 162.08,112.5 162.16,112.57 167.85,112.57 168.23,112.96 168.56,112.62 168.56,111.51 168.43,111.38 168.15,111.38 167.97,111.56 166.02,111.56 165.71,111.25 ; 2 cut-outs
GND on BOTTOM: 37.01,30.35 36.68,30.68 36.68,30.84 35.77,31.75 35.77,33.22 36.07,33.53 37.8,33.53 38.2,33.12 38.2,30.48 38.08,30.35
GND on BOTTOM: 133.61,37.77 133.54,37.83 133.54,39.85 133.39,40.01 131.4,40.01 131.09,40.31 131.09,40.87 131.19,40.97 131.7,40.97 132.36,41.63 134.55,41.63 134.75,41.43 134.75,41.1 134.8,41.05 135.99,41.05 136.05,41.1 136.78,41.1 137.04,40.84 137.04,37.9 136.91,37.77 ; 1 cut-out
