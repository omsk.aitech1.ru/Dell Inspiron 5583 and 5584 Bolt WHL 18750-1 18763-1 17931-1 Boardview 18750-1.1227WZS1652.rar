# Allegro board 18750-1.1227WZS1652.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PWR_VCCSA_ISUMN_R: length 26.4
  TOP w0.254: v1(93.61,150.6) 93.7,150.69 PR5004.1 ; v2(94.24,129.59) v1(93.7,129.08)
  L5 w0.254: v1(93.61,150.6) 93.49,150.47 93.49,150.33 93.48,150.32 93.48,149 95.58,146.89 95.58,144.19 95.3,143.91 95.3,135.23 95.84,134.7 95.84,130.25 95.25,129.67 94.31,129.67 93.73,129.08 v1(93.7,129.08)
  BOTTOM w0.254: v1(93.7,129.08) PG5001.1
PWR_VCCSA_ISUMN_RC: length 1.8
  BOTTOM w0.254: v2(73.16,151.67) PC4611.1 PR4615.2
PWR_VCCSA_ISUMNB: length 3.4
  BOTTOM w0.203: PR4620.2 74.44,150.04 v2(75.62,150.04) 75.91,150.04 75.98,149.96 76.26,149.96 76.27,149.95 PU4601.28
  BOTTOM w0.254: PC4611.2 74.45,150.06 PR4620.2
PWR_VCCSA_ISUMP: length 35.2
  TOP w0.254: v1(92.05,149.89) 92.08,149.86 PR5003.2 ; v2(75.72,146.64) 75.47,146.64 v1(75.21,146.89)
  L3 w0.254: v1(72.06,148.41) 72.06,149.07 72.44,149.45 75.46,149.45 75.62,149.61 75.67,149.61 75.94,149.89 76.74,149.89 78.24,151.38 84.53,151.38 85.4,150.52 87.1,150.52 87.63,151.06 88.67,151.06 88.86,150.87 90.75,150.87 90.94,151.06 91.37,151.06 91.67,150.76 91.67,150.6 92.05,150.22 v1(92.05,149.89)
  L5 w0.254: v1(72.06,148.41) 72.04,148.41 71.86,148.24 71.83,148.24 71.53,147.94 71.53,147.52 71.83,147.22 74.88,147.22 v1(75.21,146.89)
  BOTTOM w0.203: PR4625.1 74.45,147.07 PC4608.1 PC4605.2 74.43,148.54 PR4618.1 75.01,149.28 75.36,149.63 76.12,149.63 76.21,149.55 PU4601.27
  BOTTOM w0.254: v1(75.21,146.89) 75.14,146.97 PR4625.1
PWR_VCCSA_ISUMP_R: length 25.8
  TOP w0.254: PR5003.1 93.53,149.97 92.98,150.51 v1(92.98,150.54) ; v2(93.17,130.79) v1(93.73,130.63)
  L5 w0.254: v1(93.73,130.63) 94.31,130.05 95.1,130.05 95.46,130.41 95.46,134.54 94.92,135.07 94.92,144.07 95.2,144.35 95.2,146.73 93.09,148.84 93.09,150.43 v1(92.98,150.54)
  BOTTOM w0.254: v1(93.73,130.63) PG5011.1
PWR_VCCSA_PWM: length 31.7
  TOP w0.254: v1(96.02,136.07) v2(95.38,136.07)
  L6 w0.254: v1(75.95,151.23) 80.65,151.23 81.21,150.67 81.21,147.83 81.66,147.37 85.64,147.37 86.2,146.81 86.7,146.81 87.86,145.65 87.86,145.52 89.74,143.64 90.29,143.64 95.51,138.42 95.51,137.54 96.02,137.03 v1(96.02,136.07)
  BOTTOM w0.203: v1(75.95,151.23) 76.43,150.75 PU4601.30
  BOTTOM w0.254: v1(96.02,136.07) 96.17,135.91 PU5001.3
PWR_VCCSA_RTN: length 6.2
  TOP w0.254: PC4613.1 76.89,150.36 PR4627.2 76.13,150.34 v2(75.95,150.17) 75.92,150.14 v1(75.92,149.15) 75.85,149.15 75.59,149.4 PC4616.1 74.45,149.49 74.45,149.75 74.45,149.75 PR4602.1
  BOTTOM w0.203: PU4601.26 v1(75.92,149.15)
PWR_VCCSA_SW: length 12.8
  TOP w0.305: v4(90.71,132.75) v2(90.71,131.95)
  TOP w0.762: v4(98.28,134.27) 98.09,137.57 PC5005.2
  L3 w0.762: v4(98.28,134.27) 98.28,133.9 98.02,133.65 97.13,132.75 v4(90.71,132.75)
PWR_VCORE_BOOT: length 0.9
  BOTTOM w0.305: v1(67.19,138.38) 66.85,138.05 PU4701.5
  vias: v2(66.63,138.53)
PWR_VCORE_BOOT_RC: length 1.2
  TOP w0.508: PR4705.1 PC4707.1
PWR_VCORE_BOOTR: length 2.7
  TOP w0.305: v2(67.97,139.04) 67.97,138.51 v1(67.92,138.46) 68,138.38 68,137.8 PC4707.2
  BOTTOM w0.305: PU4701.7 67.85,138.39 v1(67.92,138.46)
PWR_VCORE_COMP: length 3.7
  TOP w0.254: PC4639.1 79.58,146.31 79.58,145.55 v2(79.59,145.54) 79.34,145.29 v1(78.95,145.29)
  BOTTOM w0.203: v1(78.95,145.29) 79.13,145.47 PU4601.16
  BOTTOM w0.254: v1(78.95,145.29) 78.95,144.83 PR4656.1
PWR_VCORE_COMP1: length 2.2
  TOP w0.254: PC4640.1 79.05,143.6 79.05,143.42 v1(78.82,143.18) 79.2,142.8 v2(79.2,142.75)
  BOTTOM w0.254: v1(78.82,143.18) 79.13,143.49 PR4656.2
PWR_VCORE_FB: length 3.6
  BOTTOM w0.203: 78.73,145.92 PU4601.17
  BOTTOM w0.254: PR4657.1 77.56,144.67 PR4660.1 78.34,144.68 PR4658.1 78.36,144.69 78.36,145.55 v2(78.37,145.56) 78.73,145.92
PWR_VCORE_FB1: length 2.4
  TOP w0.254: v2(76.1,142.62) 76.53,143.06 v1(76.53,143.16) 76.56,143.16 PC4641.1
  BOTTOM w0.254: PR4657.2 76.79,143.39 76.56,143.16 v1(76.53,143.16)
PWR_VCORE_FB2: length 15.2
  TOP w0.254: PC4644.1 77.37,143.16 v1(77.32,143.16) v2(77.71,142.76)
  L5 w0.254: v1(71.05,146.91) 70.69,146.56 70.69,145.29 72.41,143.56 73.87,143.56 73.98,143.67 76.8,143.67 v1(77.32,143.16)
  BOTTOM w0.254: PC4643.2 71.57,145.16 PR4663.2 70.86,145.86 PR4667.2 70.23,145.88 70.23,146.61 PC4642.2 70.39,146.76 70.89,146.76 v1(71.05,146.91) ; v1(77.32,143.16) 77.32,143.56 PR4660.2
PWR_VCORE_FB_RC: length 8.6
  TOP w0.254: v1(72.57,144.12) v2(72.57,143.56)
  L5 w0.254: v1(72.57,144.12) 73.03,144.58 76.95,144.58 78.08,143.44 78.08,143.18 v1(78.1,143.17)
  BOTTOM w0.254: v1(72.57,144.12) 72.24,144.12 72.12,144.24 PC4643.1 ; v1(78.1,143.17) 78.35,143.41 PR4658.2
PWR_VCORE_FCCM#: length 23.9
  TOP w0.254: v2(65.92,140.13) v1(65.92,139.57)
  L5 w0.254: v1(65.92,139.57) 65.92,141.4 68.02,143.51 68.02,144.92 68.76,145.65 69.17,145.82 69.57,146.23 69.57,147.52 71.53,149.48 74.46,149.48 74.82,149.84 75.18,149.84 75.5,150.16 76.34,150.16 76.94,149.57 76.94,147.12 v1(76.46,146.64)
  BOTTOM w0.203: v1(76.46,146.64) 76.46,146.66 PU4601.21
  BOTTOM w0.254: v1(65.92,139.57) 65.92,140.06 65.59,140.39 65.28,140.39
PWR_VCORE_FCCM#_R: length 2.4
  BOTTOM w0.254: PU4701.2 65.35,138.12 v2(65.89,138.66) 65.28,139.27 PR4706.1
PWR_VCORE_IMON: length 4.9
  TOP w0.254: v2(82.24,147.32) 82.24,147.03 81.74,146.53 PR4661.1 80.7,146.53 PC4638.1 80.58,146.08 80.22,145.72 80.22,145.36 80.19,145.33 80.19,145.31 v1(80.16,145.28)
  BOTTOM w0.203: v1(80.16,145.28) 80.16,145.73 79.93,145.96 PU4601.14
PWR_VCORE_ISUMN: length 30.4
  TOP w0.254: v1(75.88,143.16) 75.88,143.3 75.31,143.87 PR4651.2 73.87,143.87 v1(73.66,144.07) ; AFTP4601.1 v1(62.77,128.5)
  L6 w0.254: v1(73.66,144.07) 73.66,143.82 72.67,142.83 70.89,142.83 64.57,136.5 64.57,134.04 62.87,132.34 62.87,130.13 63.33,129.67 63.33,129.06 v1(62.77,128.5)
  BOTTOM w0.254: PR4652.2 76.03,143.32 75.88,143.18 v1(75.88,143.16) ; v1(73.66,144.07) 73.49,144.25 PC4631.1 ; PR4648.2 74.91,146.13 PC4634.1 74.91,145.14 PR4701.2 73.52,144.68 PC4631.1 ; PC4631.1 73.35,144.78 PR4649.2 ; PR4650.1 v1(62.77,128.5)
PWR_VCORE_ISUMN_G: length 23.4
  TOP w0.254: v1(74.49,143.16) 73.84,143.16 73.84,143.16 v2(73.83,143.16)
  L5 w0.254: v1(74.49,143.16) 74.49,142.83 74.55,142.77 74.55,142.42 74.22,142.09 72.18,142.09 71.83,141.74 71.83,136.91 69.14,134.22 69.14,132.63 69.9,131.87 69.9,129.27 69.52,128.88 67.74,128.88 67,128.13 v1(67,128.04)
  BOTTOM w0.254: v1(67,128.04) 67.34,127.71 PG4708.1 ; v1(74.49,143.16) 74.49,143.63 PR4701.1
PWR_VCORE_ISUMN_P_1: length 7.8
  TOP w0.254: v2(68.84,148.44) 69.07,148.44 69.5,148 PC4652.1 69.51,147.79 PC4635.1 v1(68.81,146.99)
  L3 w0.254: v1(68.81,146.99) 69.24,147.42 71.26,147.42 71.99,146.69 v1(71.99,145.85)
  BOTTOM w0.254: v1(71.99,145.85) 72.04,145.8 72.04,145.76 72.15,145.64 PR4649.1
PWR_VCORE_ISUMN_P_2: length 21.1
  TOP w0.254: AFTP4602.1 v1(62.82,129.39) ; v1(69.04,144.32) 69.09,144.37 69.09,145.26 69.45,145.62 PR4653.2
  L6 w0.254: v1(62.82,129.39) 62.36,129.85 62.36,132.55 64.06,134.25 64.06,136.29 64.06,136.71 69.04,141.69 v1(69.04,144.32)
  BOTTOM w0.254: PR4650.2 62.84,129.36 v1(62.82,129.39)
PWR_VCORE_ISUMN_RC: length 2.1
  TOP w0.254: PC4632.1 75.36,145.14 v2(75.36,144.83) 75.26,144.73 PR4651.1
PWR_VCORE_ISUMNA: length 3.5
  TOP w0.254: PC4632.2 76,145.72 76.28,146 v1(76.3,146) v2(76.86,146)
  BOTTOM w0.203: PU4601.20 77.04,146.56 76.94,146.46 76.94,146.44 76.51,146 76.31,146 v1(76.3,146)
  BOTTOM w0.254: 75.7,146.23 75.9,146 v1(76.3,146)
PWR_VCORE_ISUMP: length 14.1
  TOP w0.254: v1(71.4,146.36) 71.25,146.2 PR4653.1 70.31,146.88 PC4635.2 70.42,147.79 PC4652.2 70.41,147.98 70.06,148.33 v2(70.06,148.69)
  L5 w0.254: v1(71.4,146.36) 72.44,146.36 72.8,146.71 74.67,146.71 76.03,145.35 v1(76.35,145.35)
  BOTTOM w0.203: PU4601.19 77.93,146.18 77.86,146.11 77.86,146.1 77.72,145.96 77.71,145.96 77.68,145.93 77.02,145.93 76.44,145.35 v1(76.35,145.35)
  BOTTOM w0.254: v1(76.35,145.35) 76.28,145.35 76.16,145.47 PC4634.2 75.82,145.06 76.03,144.86 PR4652.1 76.02,144.63 PR4708.2
PWR_VCORE_ISUMP_G: length 23.4
  TOP w0.254: v1(75.21,143.16) 74.88,142.82 v2(74.88,142.53)
  L5 w0.254: v1(67.72,128.04) 67.72,128.31 67.9,128.5 69.68,128.5 70.28,129.11 70.28,132.03 69.52,132.79 69.52,134.06 72.22,136.75 72.22,141.58 72.34,141.71 74.37,141.71 74.93,142.27 74.93,142.77 75.21,143.05 v1(75.21,143.16)
  BOTTOM w0.254: v1(67.72,128.04) 67.34,128.42 PG4707.1 ; PR4708.1 75.21,143.74 v1(75.21,143.16)
PWR_VCORE_NTC: length 2.1
  BOTTOM w0.203: PU4601.15 79.53,145.78 79.66,145.64 v2(79.66,145.54) 79.66,144.9 PR4662.1
PWR_VCORE_NTC1: length 28.1
  TOP w0.254: v1(79.56,143.19) 79.56,143.26 v2(80,143.7) 80.55,144.25 PR4655.2
  L6 w0.254: v1(79.56,143.19) 79.56,143.53 79.06,144.02 75.67,144.02 74.88,144.81 71.52,144.81 70.76,145.57 69.31,145.57 62.61,138.87 v1(62.61,136.81)
  BOTTOM w0.254: v1(79.56,143.19) 79.56,143.21 79.9,143.55 PR4662.2 ; v1(62.61,136.81) 62.96,136.46 62.96,135.04 62.76,134.84 PR4654.1
PWR_VCORE_PROG1: length 3.2
  BOTTOM w0.203: PU4601.32 77.93,151.73 77.71,151.94 76.71,151.94 v2(76.3,152.35) 76.11,152.54 PR4629.1
PWR_VCORE_PROG2: length 3.9
  BOTTOM w0.203: 75.96,151.94 76.57,151.33 PU4601.31
  BOTTOM w0.254: 75.96,151.94 75.48,151.94 v2(75.06,152.36) 75.06,152.96 PR4628.1
PWR_VCORE_PWM: length 21.7
  TOP w0.254: v1(67.34,142.09) 67.87,142.09 67.87,142.09 v2(67.9,142.09)
  L5 w0.254: v1(67.34,142.09) 68.53,143.28 68.53,144.71 69.05,145.22 69.45,145.39 70.18,146.12 70.18,147.37 71.76,148.95 74.65,148.95 75.03,149.33 75.39,149.33 75.71,149.65 76.13,149.65 76.43,149.36 76.43,147.55 v1(76.03,147.14)
  BOTTOM w0.203: PU4601.22 76.53,147.55 76.13,147.14 v1(76.03,147.14)
  BOTTOM w0.254: 64.52,140.39 64.52,140.77 64.8,141.05 65.94,141.05 66.98,142.09 v1(67.34,142.09)
PWR_VCORE_PWM_R: length 2.1
  BOTTOM w0.254: PU4701.1 64.85,138.4 v2(64.67,138.58) 64.67,139.04 64.52,139.19 PR4702.1
PWR_VCORE_RTN: length 15.4
  TOP w0.254: v1(77.78,145.36) 78.21,145.36 v2(78.36,145.52) 78.39,145.52 78.71,145.84 PC4637.1 77.96,146.41 PR4659.2
  L3 w0.254: v1(68.81,146.25) 70.77,146.25 71.71,145.32 75.36,145.32 75.83,144.84 77.43,144.84 77.75,145.17 77.75,145.34 v1(77.78,145.36)
  BOTTOM w0.203: v1(77.78,145.36) 77.78,145.54 78.33,146.09 PU4601.18
  BOTTOM w0.254: PR4668.2 69.45,146.69 PC4642.1 69.25,146.71 68.81,146.27 v1(68.81,146.25)
PWR_VCORE_SNB: length 2.3
  TOP w0.508: PR4703.2 PC4706.1 v2(69.57,131.8)
PWR_VCORE_SW: length 2.1
  TOP w0.305: v1(64.93,130.02) v2(64.93,129.09)
  TOP w0.508: PR4703.1 65.51,130.02 v1(64.93,130.02)
PWR_VCORE_VCC: length 3.3
  TOP w0.254: v1(78.24,152.61) 78.23,152.61 78.18,152.65 77.65,152.65 PC4607.1
  BOTTOM w0.203: PU4601.34 78.73,152.33 v2(78.74,152.35) 78.49,152.61 v1(78.24,152.61) 78,152.61 77.7,152.91 PR4610.2
PWR_VCORE_VCC_R: length 1.6
  BOTTOM w0.254: PU4701.3 65.85,137.99 66.07,138.2 66.35,138.2 66.58,138.43 66.58,138.69
  vias: v2(67.44,138.91)
PWR_VCORE_VIN: length 4.8
  TOP w0.508: v1(76.91,152.55) 76.93,152.54 76.93,152.33 v2(76.6,151.99) 75.97,151.99 PC4606.1
  BOTTOM w0.203: v1(76.91,152.55) 77.57,152.55 78.33,151.8 PU4601.33
  BOTTOM w0.508: PR4612.2 v1(76.91,152.55)
PWR_VCORE_VR: length 3.3
  BOTTOM w0.203: 82.02,151.31 81.71,151 PU4601.1
  BOTTOM w0.254: 82.02,151.31 82.2,151.49 v2(82.5,151.49) 82.55,151.54 PR4614.1 PR4671.1
PWR_VCORE_VRHOT#: length 2.1
  BOTTOM w0.127: PR4607.2 80.85,152.93 80.33,152.41 80.33,152.17 80.33,152.17 PU4601.38
PWR_VDDQ:
  vias: v2(116.87,39.68) v4(113.85,39.9) v4(113.85,39.02) v4(118.34,39.89) v4(118.32,39.04) v4(119.23,39.89) v4(119.26,39.02)
PWR_VDDQ_BOOT: length 3.3
  TOP w0.254: v1(118.34,30.79) 118.85,30.79 119.08,31.01 v2(119.51,31.01) 119.46,30.96 119.46,30.2 PR5105.1
  BOTTOM w0.203: v1(118.34,30.79) 118.2,30.64 PU5102.27
PWR_VDDQ_BOOTA: length 3.2
  TOP w0.508: v2(120.55,28.73) 120.45,28.83 PR5105.2 120.45,30.58 v1(120.88,31.01)
  BOTTOM w0.508: v1(120.88,31.01) 120.75,30.89 PC5102.2
PWR_VDDQ_BOOTB: length 1.8
  BOTTOM w0.203: PU5102.25 v2(118.59,31.44)
  BOTTOM w0.508: PC5102.1 118.73,31.44 v2(118.59,31.44)
PWR_VDDQ_CS: length 2.8
  TOP w0.254: v2(113.9,30.83) 113.72,30.65 PR5102.2 113.46,29.61 113.14,29.28 v1(113.01,29.28)
  BOTTOM w0.203: v1(113.01,29.28) 113.01,29.17 113.14,29.04 PU5102.10
PWR_VDDQ_EN: length 25.5
  TOP w0.089: v1(98.78,35.08) 98.78,35.82 PG5122.2 98.89,36.26 99.06,36.44 v2(99.06,36.93) 98.94,36.93 98.4,36.4 PR5114.1
  L3 w0.089: v1(100.33,30.24) 100.33,30.28 100.76,30.7 106.44,30.7 108.12,29.01 109.19,29.01 110.23,27.97 v1(110.95,27.97)
  BOTTOM w0.089: PU5102.6 115.1,27.77 114.56,27.23 111.69,27.23 v1(110.95,27.97) ; v1(98.78,35.08) 98.86,35.08 99.58,34.36 99.58,32.72 100.33,30.82 v1(100.33,30.24)
PWR_VDDQ_FB: length 5.8
  TOP w0.254: PR5103.2 119.32,28.43 v1(119.32,27.9) 119.34,27.9 119.51,27.74 PR5104.1
  BOTTOM w0.203: v2(118.98,27.38) 118.7,27.1 116.93,27.1 116.3,27.74 PU5102.3
  BOTTOM w0.254: v1(119.32,27.9) 119.32,27.72 v2(118.98,27.38)
PWR_VDDQ_PG: length 40.4
  TOP w0.089: v1(112.25,27.95) 112.25,27.82 111.84,27.42 110.61,27.42 PR5101.2 ; PG5114.2 82.26,35.04 84.54,32.76 v2(84.54,32.34) 84.54,31.73 v1(84.31,31.5)
  L3 w0.089: v1(112.25,27.95) 112.21,27.99 112.2,27.99 111.8,28.4 110.09,28.4 109.29,29.19 108.2,29.19 106.51,30.88 98.4,30.88 98.04,30.52 85.28,30.52 v1(84.31,31.5)
  BOTTOM w0.089: v1(112.25,27.95) 112.53,27.95 112.98,28.4 113.6,28.4 113.92,28.07 PU5102.8
PWR_VDDQ_PH:
  vias: v2(115.95,34.8) v4(115.95,35.9)
PWR_VDDQ_SNB: length 2.6
  TOP w0.508: v2(113.64,36.6) PR5110.2 112.83,35.61 PC5118.1
PWR_VDDQ_TON: length 7.9
  TOP w0.254: PR5106.2 114.46,29.32 v2(114.11,28.97) 113.59,28.45 112.9,28.45 112.85,28.4 112.49,28.4 112.43,28.46 112.04,28.46 111.59,28.02 v1(111.59,27.97)
  BOTTOM w0.203: PU5102.7 114.7,27.78 114.4,27.48 112.05,27.48 111.64,27.89 111.64,27.91 111.59,27.95 v1(111.59,27.97)
PWR_VDDQ_VCC: length 1.7
  BOTTOM w0.203: v1(112.35,29.28) 112.35,29.19 112.9,28.64 PU5102.9
  vias: v2(112.67,28.83)
PWR_VDDQ_VDDQ: length 22.3
  TOP w0.254: PG5111.1 120.27,39.83 v2(120.91,39.19) 121.25,38.85 v1(122.88,38.85) ; PR5103.1 118.62,27.96 v1(118.65,27.94)
  L6 w0.254: v1(122.88,38.85) 122.74,38.71 122.74,36.83 121.85,35.94 121.85,28.8 121.72,28.68 118.88,28.68 118.65,28.45 v1(118.65,27.94)
  BOTTOM w0.203: PU5102.2 116.7,27.79 117.08,27.41 118.4,27.41 118.67,27.67 118.67,27.84 118.65,27.86 v1(118.65,27.94)
PWR_VDDQ_VLDOIN: length 11.2
  TOP w0.254: v1(118.34,30.15) 118.32,30.13 PC5114.1
  L6 w0.508: v1(118.34,30.15) 118.9,30.15 120.98,32.23 120.98,36.89 v1(122.22,38.13)
  BOTTOM w0.203: PU5102.28 118.25,30.24 v1(118.34,30.15)
  vias: v2(122.28,40.84)
PWR_VDDQ_VTTREF: length 2.3
  TOP w0.305: PC5123.1 117.96,27.99 v1(118.01,27.94) 117.76,27.69 v2(117.5,27.69)
  BOTTOM w0.203: v1(118.01,27.94) 117.89,28.07 PU5102.1
PWR_VGA_CORE_EN#: length 4.1
  BOTTOM w0.254: v2(103.56,143.61) R8710.1 103.56,142.74 104.44,142.74 104.56,142.62 ; 104.56,142.62 Q8705.6 ; 104.56,142.62 104.67,142.73 105.03,142.73 105.21,142.55 Q8705.5
PWR_VGA_CORE_PSI: length 9.3
  TOP w0.254: v1(147.4,79.07) 147.4,79.61 v2(147.32,79.68) 146.97,79.68 PR8564.1 146.43,78.76 PC8556.1 148.79,78.4 v1(149.38,77.8)
  BOTTOM w0.203: PU8514.4 147,79.55 147.4,79.15 v1(147.4,79.07)
  BOTTOM w0.254: v1(149.38,77.8) 149.53,77.95 149.53,78.51 150.2,79.18 PR8563.2 PR8522.2
PWR_VGA_CORE_VID: length 3.3
  BOTTOM w0.203: PU8514.5 146.71,78.76 147.13,78.33 v2(147.3,78.33)
  BOTTOM w0.254: PR8510.2 148.54,79.17 148.11,78.74 PC8552.2 148.03,78.33 v2(147.3,78.33)
PWR_VGA_GDDR_EN: length 7.4
  TOP w0.089: C8803.1 109.38,151.26 109.05,151.59 Q8702.2 108,151.59 107.7,151.89 v1(107.7,152.6)
  BOTTOM w0.089: v1(107.7,152.6) 107.42,152.6 107.19,152.83 R8807.2 R8604.1 107.95,153.19 108.23,152.91 v2(108.23,152.38) 108.66,152.38 109.36,151.68 PU8602.11
PWR_VGA_GDDR_EN_L: length 11.6
  TOP w0.089: v1(105.06,149.37) 104.48,148.79 v2(104.48,147.1) 104.55,147.1 105.3,146.35 U8803.4
  L6 w0.089: v1(105.06,149.37) 104.7,149.72 104.7,152.12 107.19,154.61 v1(107.19,154.71)
  BOTTOM w0.089: R8807.1 v1(107.19,154.71)
PWR_VGA_NVDD_SS: length 3.3
  TOP w0.254: v2(142.26,80.97) 142.55,80.97 142.57,80.95 142.73,80.95 143.01,80.67 PR8573.1 143.85,80.67 PC8573.1 143.93,79.92 PR8512.1 PR8513.1
PWR_VGA_NVVDD_BOOT1_A: length 2
  BOTTOM w0.254: v2(150.78,81.15) 150.49,81.44 PC8572.1
  BOTTOM w0.508: PC8572.1 149.39,81.44 149.26,81.31 PR8572.2
PWR_VGA_NVVDD_BOOT2_A: length 1
  BOTTOM w0.508: PC8575.1 142.57,82.22 PR8574.2
PWR_VGA_NVVDD_EN: length 127.6
  TOP w0.089: U8804.4 v1(97.16,151.93) ; v1(105.06,144.58) v2(105.06,144.02)
  L6 w0.089: v1(154.49,77.34) 153.49,76.34 143.21,76.34 142.53,77.02 140.26,77.02 140.26,77.02 139.78,77.02 136.36,77.02 133.73,79.64 133.73,86.52 133.25,87.01 133.25,87.01 133.15,87.11 133.15,90.45 133.56,90.86 133.56,91.75 133.13,92.18 132.64,92.18 131.87,92.95 131.87,104.33 132.66,105.12 132.66,106.21 131.35,107.52 131.35,110.87 130.08,112.14 130.08,114.28 126.69,117.66 126.03,117.66 125.19,118.5 125.19,121.9 120.31,126.79 120.31,136.61 115.73,141.19 112.94,141.19 112.94,141.19 112.66,141.19 110.82,143.04 108.99,143.04 108.78,143.24 108.78,143.24 107.95,144.08 105.56,144.08 v1(105.06,144.58) 105.06,146.3 103.73,147.63 101.96,147.63 97.66,151.93 v1(97.16,151.93)
  BOTTOM w0.089: Q8705.2 105.21,144.28 105.06,144.43 v1(105.06,144.58) ; PR8526.1 149.83,80.71 151.63,80.71 151.63,80.71 151.9,80.71 152.3,80.32 152.3,77.98 152.45,77.83 154,77.83 v1(154.49,77.34)
PWR_VGA_NVVDD_EN_R: length 2.2
  BOTTOM w0.089: PR8526.2 148.39,80.34 147.75,79.71 v2(147.63,79.71) 147.48,79.71 147.24,79.95 PU8514.3
PWR_VGA_NVVDD_HG1: length 18.4
  TOP w0.762: PU8510.1 155.98,83.48 v4(156.09,83.36) ; v4(155.76,89.05) 155.76,89.56 v2(155.55,89.76)
  L3 w0.762: v4(155.76,89.05) 155.76,83.7 v4(156.09,83.36) 153.43,80.7 149.48,80.7 149.16,80.37 v4(147.6,80.37)
  BOTTOM w0.762: PU8512.1 155.98,88.83 v4(155.76,89.05)
PWR_VGA_NVVDD_HG2: length 14.8
  TOP w0.762: v2(140.38,90.34) v4(140.38,89.55) 140.2,89.55 139.44,88.79 PU8515.1
  L3 w0.762: v4(142.35,80.32) 142.34,80.32 142.34,81.94 141.35,82.93 140.31,82.93 139.75,83.49 v4(139.75,83.5) 140.38,84.13 v4(140.38,89.55)
  BOTTOM w0.762: v4(139.75,83.5) 139.74,83.52 139.73,83.52 139.44,83.8 PU8516.1
PWR_VGA_NVVDD_LGATE1: length 14.1
  TOP w0.508: PR8508.1 146.67,82.38 v4(146.03,82.38)
  TOP w0.762: v2(150.07,82.53) 150.07,83.27 v4(150.08,83.29) PU8510.8
  L3 w0.762: v4(149.1,88.44) 149.46,88.44 150.12,87.78 150.12,83.47 150.08,83.44 v4(150.08,83.29) 149.96,83.17 149.96,82.88 149.46,82.37 148.74,82.37 148.74,82.38 v4(146.03,82.38)
  BOTTOM w0.762: v4(149.1,88.44) 149.74,88.44 150.08,88.1 PU8512.8
PWR_VGA_NVVDD_LGATE2: length 10.9
  TOP w0.305: v2(144,82.86) v4(144.66,82.86)
  TOP w0.762: PU8515.8 145.33,88.74 v4(145.93,89.33)
  L3 w0.762: v4(144.66,82.86) 144.66,88.06 v4(145.93,89.33)
  BOTTOM w0.762: v4(144.66,82.86) 145.33,83.53 PU8516.8
PWR_VGA_NVVDD_PG: length 38.7
  L6 w0.089: v1(132.36,99.48) 132.06,99.18 132.06,93.01 132.72,92.36 133.2,92.36 133.73,91.82 133.73,90.79 133.33,90.38 133.33,87.18 133.91,86.6 133.91,80.95 136.73,78.13 v1(136.73,77.51)
  BOTTOM w0.089: U7302.1 135.9,98.45 135.79,98.55 133.29,98.55 v1(132.36,99.48) ; v1(136.73,77.51) 136.73,77.85 136.58,78 136.58,78.51 137.3,79.23 137.58,79.23 137.8,79.45 137.8,79.78 137.96,79.94 v2(138.15,79.94) 138.22,79.94 138.59,79.57 140.53,79.57 PR8530.2 141.91,80.01 142.13,79.79 142.57,79.79 142.72,79.95 PU8514.13
PWR_VGA_NVVDD_PHASE1: length 14.8
  L3 w0.762: v4(150.88,81.97) 153.24,81.97 154.69,83.41 v4(154.69,89.46)
  BOTTOM w0.508: 146.88,81.93 147.31,82.36 PC8572.2 150.49,82.36 v4(150.88,81.97)
  vias: v2(151.77,90.98) v4(149.36,92.58) v4(150.22,92.58) v4(151.11,92.58) v4(151.97,92.58) v4(153.06,92.2) v4(153.06,91.34) v4(153.06,90.48) v4(153.06,89.59)
PWR_VGA_NVVDD_PHASE2: length 7.3
  L3 w0.762: v4(141.43,89.54) 141.43,85.32 143.21,83.54 v4(143.21,82.96)
  vias: v2(142.37,91.87) v4(141.4,92.13) v4(141.4,91.26) v4(141.43,90.43) v4(142.32,92.58) v4(143.18,92.58) v4(144.05,92.58) v4(144.94,92.58)
PWR_VGA_NVVDD_PVCC: length 2.4
  TOP w0.305: v1(145.21,82.23) 145.21,82.51 145.41,82.71 145.42,82.71 v2(145.44,82.73)
  TOP w0.508: PR8551.2 PC8550.1 145.48,81.37 145.21,82.02 v1(145.21,82.23)
PWR_VGA_NVVDD_REFADJ: length 3.8
  TOP w0.254: v2(147.86,75.64) 147.07,76.43 PR8558.2 146.97,77.72 v1(146.97,77.73)
  BOTTOM w0.203: PU8514.6 146.23,78.46 v1(146.97,77.73)
PWR_VGA_NVVDD_REFADJ_R: length 6.3
  TOP w0.254: PR8558.1 146.2,75.57 PR8557.2 145.4,75.55 PR8556.2 145.4,75.07 144.57,74.23 142.43,74.23 v2(142.4,74.27) PC8555.1
PWR_VGA_NVVDD_REFIN: length 11.1
  TOP w0.203: v1(146.1,77.71) 146.15,77.66 146.15,76.44 PR8557.1
  TOP w0.254: v2(140,76.07) 140.13,76.07 v1(140.47,76.4) 140.92,76.86 PC8554.1 141.56,77.04 PR8559.2
  BOTTOM w0.203: v1(146.1,77.71) 146.07,77.71 145.62,78.17 PU8514.7
  BOTTOM w0.254: v1(146.1,77.71) 146.1,77.32 145.49,76.71 143.16,76.71 142.9,76.96 140.85,76.96 140.47,76.58 v1(140.47,76.4)
PWR_VGA_NVVDD_REFIN_R: length 2.2
  TOP w0.254: PR8560.2 143.11,77.55 142.93,77.37 v2(142.47,77.37) 142.19,77.37 141.68,77.88 PR8559.1
PWR_VGA_NVVDD_TON: length 2.5
  TOP w0.254: PR8553.2 144.46,76.29 v2(144.46,77.13) 144.46,77.56 v1(144.63,77.73)
  BOTTOM w0.203: v1(144.63,77.73) 144.63,77.93 144.82,78.12 PU8514.9
PWR_VGA_NVVDD_TON_1: length 2.7
  TOP w0.254: PC8551.2 143.83,76.35 PR8552.2 ; PR8552.2 143.83,74.91 v2(143.64,74.73) ; PR8552.2 144.2,75.61 144.53,75.29 PR8553.1
PWR_VGA_NVVDD_VREF: length 7.7
  TOP w0.254: PR8556.1 145.4,76.62 145.67,76.89 v2(145.67,77.28) 145.27,77.68 v1(145.27,77.7)
  BOTTOM w0.203: v1(145.27,77.7) 145.22,77.74 PU8514.8
  BOTTOM w0.254: v1(145.27,77.7) 145.27,77.45 145.04,77.22 143.77,77.22 143.51,77.47 141.4,77.47 141.02,77.85 PC8553.2
PWR_VGA_NVVDD_VSEN: length 5.5
  TOP w0.254: PR8503.2 PR8576.1 140.8,78.84 v1(140.39,78.44) ; v1(140.39,78.44) 140.05,78.1 v2(140.05,77.98) ; v1(140.39,78.44) 140.06,78.77 PC8559.1 139.96,79.1 PR8504.2 139.2,79.02 PC8558.1
  BOTTOM w0.254: v1(140.39,78.44) 140.39,78.54 139.78,79.15 PR8517.1
PWR_VGA_NVVDD_VSEN_N: length 17.8
  TOP w0.254: PC8555.2 140.53,74.93 140.41,74.93 v2(140.39,74.92) 140.39,74.92 140.19,74.92 139.46,75.65 139.46,76.33 v1(139.55,76.42) 139.55,76.62 139.2,76.97 PC8558.2 ; PC8558.2 138.61,78.11 PR8505.1 ; PC8558.2 139.53,77.52 PC8554.2 140.56,77.59 140.56,77.66 141.29,78.39 141.92,78.39 142.18,78.12 v1(142.24,78.12) 142.78,78.12 143.06,78.41 PR8560.1 144.38,78.41 PC8560.1
  BOTTOM w0.203: v1(142.24,78.12) 143.63,78.12 143.97,78.46 PU8514.10
  BOTTOM w0.254: PR8520.1 139.63,76.49 v1(139.55,76.42) ; PC8553.1 141.23,79.22 141.53,78.92 141.53,78.39 141.8,78.12 v1(142.24,78.12)
PWR_VGA_NVVDD_VSEN_P: length 3.7
  TOP w0.254: PR8503.1 141.94,79.53 142.3,79.53 v1(142.47,79.36) 143.02,79.91 PR8512.2
  BOTTOM w0.203: PU8514.12 143.18,79.55
  BOTTOM w0.254: v2(141.91,79.36) v1(142.47,79.36) 142.77,79.36 142.95,79.55 143.18,79.55
PWR_VGA_NVVDD_VSNS/SS: length 3.7
  TOP w0.254: PR8513.2 142.67,78.74 142.29,78.74 142.28,78.76 v1(142.26,78.76) 142.26,78.83 142.07,79.02 PR8576.2
  BOTTOM w0.203: PU8514.11 143.39,79.15 143.04,78.8 v2(143.04,78.55) 142.54,78.55 142.33,78.76 v1(142.26,78.76)
PWR_VGA_SNUB1:
  vias: v2(148.34,92.34)
PWR_VGA_SNUB2:
  vias: v2(146.66,91.52)
Q501_G: length 5.5
  BOTTOM w0.089: v2(105.43,37.02) 105.67,37.26 105.67,37.87 105.06,38.48 Q502.G ; Q502.G 103.94,38.73 103.81,38.6 R506.2 ; Q502.G 104.73,39.05 Q501.D
Q5503_B: length 2.2
  BOTTOM w0.089: Q5502.B 136.26,91.57 135.84,92 R5554.2 135.21,92.48 v2(134.95,92.74)
Q5503_C: length 13.3
  BOTTOM w0.089: Q5502.C 136.53,89.3 136.35,89.49 v2(136.02,89.49) 135.66,89.49 135.25,89.07 134.93,89.07 134.37,88.51 134.37,85.38 133.48,84.49 133.48,84.35 133.48,80.68 134.45,79.72 R5546.1
Q5503_E: length 4.3
  BOTTOM w0.089: R5551.1 139.53,91.14 139.21,91.45 Q5502.E 138.16,89.55 v2(138.26,89.46)
Q5504_B: length 12.7
  TOP w0.089: Q5501.B 224.08,67.85 223.48,68.45 222.68,68.45 222.56,68.33 222.56,67.54 222.35,67.34 221.82,67.34 221.19,66.7 v2(214.84,66.7) 214.66,66.7 214.51,66.55 R5553.2
Q5504_C: length 5
  TOP w0.089: R5548.1 222.1,66.7 222.67,67.27 223.65,67.27 224.18,66.74 Q5501.C 223.65,65.17 v2(223.65,64.72)
Q5505_E: length 4.4
  TOP w0.089: Q5501.E 223.47,67.85 225.19,66.13 v2(225.19,65.61) 224.56,64.99 R5550.1
Q6205_Q: length 3
  BOTTOM w0.127: v2(96.8,32.13) R6503.2 96.8,30.18 97.03,29.95 Q6503.D
Q6407_B: length 19.8
  TOP w0.089: Q6407.1 43.3,77.4 44.33,77.4 44.83,77.9 R6405.1 45.04,76.56 46.74,74.86 50.55,74.86 51.24,74.16 51.24,71.86 50.8,71.43 50.8,71.05 50.55,70.79 v2(50.42,70.79) 50.17,70.79 48.82,69.44 Q6408.C
Q6407_C: length 2.6
  TOP w0.089: Q6407.3 v2(41.66,80.06) 40.95,80.06 R6413.2
REGOUT:
  vias: v1(49.23,85.64) v2(49.84,85.73)
RESET_OUT#: length 265.7
  TOP w0.089: U2401.73 39.65,63.29 40.78,64.43 ED1705.2 42.31,63.22 42.82,63.22 44.78,65.18 44.78,68.55 44.73,68.6 44.73,69.38 45.65,70.3 46.75,70.3 46.93,70.49 47.98,70.49 v1(50.45,72.96) ; RN1703.3 157.28,67.83 158.01,67.11 158.01,63.01 159.67,61.35 160.79,61.35 164.47,57.67 v1(164.47,57.46) ; v1(101.73,87.81) 101.37,87.45 101.37,74.86 102.63,73.6 102.63,72.44 101.69,71.5 66.79,71.5 63,75.28 59.88,75.28 59.59,74.99 59.59,74.88 v1(59.57,74.86)
  L3 w0.089: v1(121.84,78.53) 120.7,78.53 120.53,78.37 120.16,77.99 120.12,77.95 118.34,77.95 118.18,77.95 117.88,77.95 116.61,79.22 116.61,81.89 114.04,84.47 108.96,84.47 108.64,84.15 106.75,84.15 105.55,85.35 104.75,85.35 104.47,85.63 103.79,85.63 103.17,85.63 102.72,86.08 102.72,86.41 102.38,86.75 101.63,86.75 101.37,87.01 101.37,87.51 101.67,87.81 v1(101.73,87.81)
  L5 w0.089: v1(129.7,109.45) 129.7,109.22 128.83,108.36 128.83,106.28 130.64,104.47 130.64,99.32 131.09,98.86 131.09,96.66 131.24,96.51 131.24,93.1 131.55,92.79 131.55,76.01 v1(132,75.56)
  L6 w0.089: v1(101.73,87.81) 101.67,87.81 101.37,87.51 101.37,87.01 101.64,86.74 102.05,86.74 102.32,86.46 102.32,85.96 102.12,85.76 102.12,83.36 102.24,83.24 102.24,82.48 112.27,72.44 112.27,69.82 126.27,55.82 162.84,55.82 v1(164.47,57.46)
  BOTTOM w0.089: v1(59.57,74.86) 54.97,74.86 52.66,72.54 50.86,72.54 v1(50.45,72.96) ; v1(129.7,109.45) 129.17,108.92 R2616.2 128.7,109.15 C2614.1 128.04,110.29 127.6,110.29 Q2602.G ; CPU1.BP31 101.27,87.55 101.54,87.82 101.72,87.82 v1(101.73,87.81) ; v1(121.84,78.53) 122.17,78.21 v2(123.98,78.21) 124.41,77.78 129.79,77.78 v1(132,75.56)
REXT1: length 2.8
  TOP w0.127: U5802.20 54.5,115.07 55.07,114.5 R5804.1 55.73,113.72 v2(55.63,113.62)
RING2_HPMIC1: length 13.8
  TOP w1.016: R2906.2 15.95,9.58 v2(15.17,8.79) 5.57,8.79 HPMIC1.3
RSET: length 4.1
  TOP w0.089: U3101.31 45.09,86.29 v1(45.07,86.31)
  BOTTOM w0.152: R3102.1 42.8,87.02 44.36,87.02 v2(44.64,86.74) v1(45.07,86.31)
RSMRST_PWRGD#: length 268.5
  TOP w0.089: v1(25.45,57.51) 25.28,57.51 24.54,58.24 R4030.2 ; v1(96.14,147.37) 96.32,147.19 96.32,144.2 97.03,143.49 97.03,141.35 96.19,140.51 95.35,140.51 95.13,140.29 R4029.2 ; v1(79.12,37.97) v2(79.12,37.26) 79.12,37.19 79,37.06 R4033.2
  L5 w0.089: v1(79.12,37.97) 78.44,37.29 76.61,37.29 76.38,37.06 64.29,37.06 62.77,38.58 60.68,38.58 59.34,39.91 53.93,39.91 51.86,41.98 51.76,42.08 39.68,42.08 36.17,38.57 36.17,37.79 34.3,35.92 34.22,35.92 33.24,34.95 28.14,34.95 27.68,34.49 27.68,33.71 27.35,33.38 26.26,32.29 21.96,32.29 21.14,33.12 21.14,46.55 21.53,46.94 21.95,47.36 21.95,50.42 22.39,50.86 22.39,52.32 23.31,53.25 23.31,54.51 24.74,55.94 24.74,56.8 v1(25.45,57.51) 26.26,57.51 28.27,59.51 28.27,61.98 28.22,62.02 28.22,64.19 31.95,67.92 31.95,68.69 32.78,69.52 33.8,69.52 35.52,71.24 36.36,71.24 39.42,74.3 39.42,75.42 40.98,76.98 40.98,106.27 42.07,107.37 42.59,107.37 43.75,108.52 43.75,112.06 45.36,113.67 46.66,113.67 46.97,113.98 46.97,115.07 49.66,117.76 49.66,118.4 50.92,119.66 50.92,123.51 50.2,124.23 49.94,124.23 49.91,124.25 49.56,124.25 48.82,124.99 48.82,126.91 56.44,134.53 56.44,136.54 56.44,137.38 57.87,138.81 62,138.81 63.4,140.21 63.4,141.05 66.57,144.22 66.57,145.52 67.06,146.01 67.06,149.07 68.94,150.95 72.42,150.95 74.96,153.49 74.96,154.81 75.7,155.55 81.18,155.55 82.01,154.72 82.01,153.36 84.36,151 91.85,151 92.03,151.19 94.28,151.19 95.89,149.58 95.89,147.63 v1(96.14,147.37)
  BOTTOM w0.089: D4002.K 82.2,39.8 81.77,39.37 81.77,38.38 81.59,38.2 79.35,38.2 v1(79.12,37.97) 78.18,37.03 R4031.2
RTC_3P3_EN_G: length 13.2
  TOP w0.089: Q2510.D 155.44,91.86 156.97,90.32 157.51,90.32 157.61,90.22 v2(158.12,90.22) 158.55,90.22 159.21,90.88 160.4,90.88 161.23,91.7 161.23,92.51 161.35,92.64 162.64,92.64 163.32,93.31 164.26,93.31 165.15,92.42 R2506.1
RTC_DET#: length 90.3
  TOP w0.089: v1(159.57,91.85) 159.36,91.64 156.49,91.64 155.12,93.02 Q2505.D
  L5 w0.089: v1(159.57,91.85) 159.57,90.85 160.52,89.89 160.52,85.45 161.01,84.96 161.01,81.13 159.36,79.48 159.36,77.15 157.53,75.31 138.77,75.31 137.16,76.92 137.16,77.85 136.98,78.02 136.98,78.02 135.74,79.26 135.74,88.24 137.8,90.3 137.8,91.34 137.44,91.7 134.52,91.7 133.84,92.38 v1(133.84,92.64)
  BOTTOM w0.089: v1(133.84,92.64) 133.56,92.36 129.51,92.36 129.06,92.81 127.91,92.81 127.63,93.09 125.43,93.09 R1554.2 124.57,93.32 122.02,93.32 121.11,92.41 120.53,92.41 120.23,92.7 v2(119.74,92.7) 119.57,92.54 115.92,92.54 115.18,93.29 114.84,93.34 114.58,93.6 113.22,93.6 113.17,93.56 CPU1.CP22
RTC_RST#: length 99.1
  TOP w0.127: RN1801.4 168.53,67.06 C1806.1 168.72,65.75 G1801.2 168.43,65.39 168.43,64.89 168.15,64.61 167.03,64.61 166.94,64.52 166.94,63.58 167.52,63 ED1802.2 166.62,62.55 166.39,62.29 166.39,61.44 v2(166.65,61.18) 167.38,60.45 167.38,57.84 167.3,57.77 167.3,57.16 v1(167.74,56.72)
  L6 w0.127: v1(167.74,56.72) 167.33,56.3 166,56.3 165.37,56.94 164.53,56.94 163.66,56.07 163.43,56.07 162.94,55.58 126.16,55.58 125.56,56.19 125.56,56.21 111.57,70.19 111.57,72.72 104.55,79.74 103.36,79.74 102,81.1 102,82.46 101.88,82.58 101.88,86.29 v1(101.91,86.31)
  BOTTOM w0.127: CPU1.BR34 101.96,86.23 101.91,86.29 101.91,86.31 v1(101.91,86.31)
RTCRST_ON: length 359.3
  TOP w0.089: Q2507.G 162.52,92.09 163.2,91.42 163.2,90.48 164.97,88.71 D2502.K 165.58,89.22 R2518.1 166.22,89.54 v1(166.88,90.2) 166.88,90.79 R2567.1 ; v1(131.88,41.35) 131.48,41.75 131.04,41.75 130.79,41.5 v2(130.79,39.24) 130.79,36.07 v1(132.29,34.57) ; v1(24.84,60.95) 24.38,60.49 U2401.31
  L3 w0.089: v1(166.88,90.2) 166.43,89.75 166.43,82.1 169.11,79.41 170.48,79.41 175.63,74.26 175.63,73.98 176.74,72.87 176.74,71.02 177.94,69.82 179.27,69.82 181.8,67.29 181.8,64.16 184.7,61.27 197.72,61.27 198.93,62.49 207.81,62.49 208.41,61.89 210.47,61.89 213.4,58.95 214.1,58.95 218.35,54.71 218.35,39.17 217.94,38.76 216.46,38.76 215.96,38.26 215.95,38.26 215.39,37.7 213.05,37.7 212.55,38.2 209.23,38.2 205.73,34.71 200.2,34.71 198.48,32.99 198.13,32.99 175.67,32.99 172.83,35.84 168.25,35.84 167.89,36.2 166.84,36.2 166.84,36.2 166.37,36.2 165.63,35.47 150.69,35.47 149.5,34.27 145.18,34.27 144.86,34.6 132.31,34.6 v1(132.29,34.57)
  L5 w0.089: v1(24.84,60.95) 24.29,60.95 18.88,55.53 18.88,50.24 18.13,49.5 18.13,36.78 19.38,35.53 19.38,32.17 22.57,28.98 26.57,28.98 29.11,31.52 32.88,31.52 35.12,33.76 35.12,34.19 35.48,34.54 36.53,34.54 37.37,33.71 52.4,33.71 54.17,35.48 76.1,35.48 76.92,36.3 83.57,36.3 84.18,36.91 84.33,36.91 93.4,36.91 94.56,38.07 95.92,38.07 96.5,37.49 96.66,37.49 97.23,36.91 97.44,36.7 101.33,36.7 102.12,37.49 103.46,37.49 103.82,37.12 105.37,37.12 105.62,37.37 105.62,37.85 107.26,39.49 107.26,41.86 108.5,43.11 110.15,43.11 111.44,44.39 127.03,44.39 129.44,41.99 131.24,41.99 v1(131.88,41.35)
RUNPWROK: length 313.3
  TOP w0.089: v1(87.85,128.9) 87.35,129.4 87.35,130.94 87.63,131.22 87.63,137.7 91.14,141.21 v1(91.14,145.49) ; ED1706.2 31.55,57.29 31.16,57.69 U2401.48 31.16,61.71 30,62.87 29.63,62.87 29.17,63.32 29.17,64.31 29.71,64.85 31.68,64.85 31.92,65.1 31.92,65.46 31.47,65.91 31.47,68.47 30.86,69.08 28.93,69.08 28.68,68.83 27.84,68.83 27.55,69.12 v1(27.55,70.12) ; v1(85.07,31.57) 85.07,33.34 82.83,35.58 82.83,37.09 83.11,37.36 R4011.2 83.14,37.75 83.14,40.64 v1(83.82,41.33)
  L3 w0.089: v1(87.85,128.9) 87.61,128.66 87.61,125.35 89.28,123.67 89.28,118.19 94.54,112.93 v1(94.54,112.7)
  L5 w0.089: v1(49.97,82.14) 50.02,82.19 50.02,87.76 49.28,88.5 49.28,90.76 52.28,93.76 52.28,94.77 53.72,96.22 53.72,99.94 55.78,101.99 55.78,109.29 58.12,111.63 61.09,111.63 66.8,117.34 66.81,117.34 66.98,117.51 87.83,117.51 88.51,116.83 90.41,116.83 v1(94.54,112.7) ; v1(91.14,145.49) 91.14,146.97 89.97,148.13 89.97,149.25 88.4,150.83 84.29,150.83 81.49,153.63 v1(81.49,154.51)
  L6 w0.089: v1(27.55,70.12) 23.83,66.4 23.83,61.53 20.31,58.01 20.31,51.44 20.68,51.06 20.68,42.88 21.23,42.33 21.23,36.47 21.66,36.04 21.66,27.61 23.1,26.17 34.24,26.17 36.67,28.6 39.17,28.6 41.11,30.53 84.03,30.53 v1(85.07,31.57)
  BOTTOM w0.089: R4002.1 82.98,152.6 R4005.2 84.08,153.75 84.08,154.61 83.42,155.27 82.63,155.27 81.87,154.51 v1(81.49,154.51) ; v1(27.55,70.12) 27.94,70.51 28.33,70.9 28.55,70.9 31.72,74.06 34.48,74.06 34.98,74.56 36.28,74.56 36.91,75.19 37.78,75.19 38.03,75.44 38.4,75.81 40.57,75.81 41.2,76.44 46.56,76.44 47.32,75.67 48.45,75.67 49.81,77.03 49.81,78.6 50.3,79.09 50.3,79.44 50.05,79.69 49.87,79.69 49.47,80.1 49.47,80.76 49.81,81.1 49.81,81.94 49.97,82.1 v1(49.97,82.14) ; v1(94.54,112.7) v2(94.54,113.49) 94.54,114.46 R1716.1 ; v1(83.82,41.33) 83.82,40.64 84.23,40.23 D4002.A 84.4,40.23 D4003.A
SA0_CHA_DIM0: length 4.1
  TOP w0.089: R1204.1 96.5,45.49 96.5,44.76 v1(96.08,44.34) 95.91,44.17 R1205.1
  BOTTOM w0.089: DM1.256 v1(96.08,44.34)
SA0_CHB_DIM0: length 5.6
  TOP w0.089: R1302.1 173.46,45.14 v1(173.82,45.49) 173.38,45.92 R1303.1
  BOTTOM w0.089: DM2.256 172.28,44.87 172.9,45.49 v1(173.82,45.49)
SA1_CHA_DIM0: length 3.5
  TOP w0.089: v1(97.18,44.34) 96.95,44.56 R1210.1 96.9,45.04 R1208.1
  BOTTOM w0.089: DM1.260 97.08,44.23 v1(97.18,44.34)
SA1_CHB_DIM0: length 3.1
  TOP w0.089: R1306.1 172.39,44.38 R1307.1 173.44,44.07 v1(173.81,44.07)
  BOTTOM w0.089: v1(173.81,44.07) 173.79,44.05 173.5,44.05 173.28,43.83 DM2.260
SA2_CHA_DIM0: length 3.2
  TOP w0.089: v1(73.58,41.63) 74.75,41.63 R1212.1 R1211.1
  BOTTOM w0.089: DM1.166 73.58,41.63 v1(73.58,41.63)
SA2_CHB_DIM0: length 5.1
  TOP w0.089: v1(149.71,45.02) 150.06,45.02 150.5,44.58 150.5,43.94 R1311.1 R1310.1
  BOTTOM w0.089: DM2.166 149.78,43.98 149.61,44.15 149.61,44.91 v1(149.71,45.02)
SATA1_ODD_PRSNT#: length 158.4
  TOP w0.089: R1617.2 195.15,37.01 191.04,37.01 190.38,37.67 187.89,37.67 186.91,38.65 186.17,38.65 185.56,39.26 185.54,39.26 185.29,39.51 185.29,39.53 185.17,39.65 185.17,41.1 185.02,41.25 R6004.1 182.15,41.25 181.33,40.44 172.6,40.44 172.24,40.79 172.24,41.48 172.85,42.09 176.02,42.09 176.38,42.45 176.38,48.61 v2(176.51,48.74) 177.19,49.42 177.19,51.56 v1(178.23,52.6)
  L6 w0.089: v1(178.23,52.6) 178.18,52.6 177.78,53.01 177.78,54.81 177.96,54.99 177.96,57.35 177.72,57.58 176.74,58.56 176.74,64.19 175.58,65.35 172.07,65.35 171.88,65.54 170.7,65.54 170.49,65.33 169.99,65.33 169.36,65.96 159.95,65.96 158.83,67.08 130.98,67.08 128.37,69.7 126.44,69.7 123.68,72.47 123.68,81.46 123.88,81.66 123.88,90 122.46,91.42 122.46,97.69 122.73,97.97 122.73,102.06 119.63,105.16 116.19,105.16 115.74,105.61 114.03,105.61 112.25,103.83 112.25,102.65 v1(111.08,101.49)
  BOTTOM w0.089: CPU1.CM10 111.08,101.31 v1(111.08,101.49)
SATA_LED#: length 267.9
  TOP w0.254: v1(56.92,32.97) v2(56.92,32.18) 56.92,29.87 56.24,29.19 56.24,28.86 55.78,28.4 R1606.2 55.3,28.27 45.8,28.27 45.64,28.12 40.82,28.12 34.63,21.93 34.61,21.88 D6401.1
  L5 w0.254: v1(56.92,32.97) 57.41,32.49 60.61,32.49 61.22,33.1 82.35,33.1 83.12,33.87 96.85,33.87 96.85,33.87 97.27,33.87 98,33.15 104.81,33.15 108.44,36.77 108.44,38.28 109.76,39.6 109.76,41.69 111.8,43.74 126.24,43.74 131.1,38.88 151.02,38.88 151.79,39.65 v1(153.19,39.65)
  L6 w0.254: v1(118.6,102.74) 119.24,102.1 119.24,99.37 118.89,99.02 118.89,94.15 119.13,93.91 119.13,91.41 118.58,90.87 118.58,87.06 118.58,87.06 118.58,86.81 116.89,85.12 116.89,74.99 117.46,74.42 124.73,67.15 124.98,67.15 127.21,67.15 130.91,63.45 161.08,63.45 161.59,62.94 167.24,62.94 169.65,60.54 169.65,59.9 171.24,58.31 171.24,55.37 170.82,54.95 170.82,43.98 169.72,42.88 155.22,42.88 153.11,40.77 153.11,39.73 v1(153.19,39.65)
  BOTTOM w0.076: CPU1.CN7 112.81,102.5 113.05,102.5 113.11,102.48 113.35,102.48 113.51,102.54 113.94,102.54
  BOTTOM w0.127: 116.96,102.68 115.97,102.68 115.83,102.54 113.94,102.54
  BOTTOM w0.254: 116.96,102.68 117.23,102.68 117.75,103.2 118.17,103.2 118.6,102.78 v1(118.6,102.74)
SATA_LED#_D: length 38.1
  TOP w0.254: D6401.3 33.58,18.99 32.67,18.99 v2(32.64,18.96) 32.1,18.42 v1(31.91,18.42) 31.88,18.44 31.88,19.61 R6415.2
  BOTTOM w0.254: v1(31.91,18.42) 29.63,19.36 25.52,19.36 23.31,21.57 23.07,21.57 22.81,21.82 17.1,21.82 13.39,25.53 13.39,26.44 14.61,27.66 14.61,28.88 15.67,29.95 17.81,29.95 19,31.14 19.8,31.14 20.4,31.73 20.4,33.29 Q6401.S
SATA_ODD_DA#_C: length 3.6
  TOP w0.089: TP6001.1 191.11,32.92 v1(191.11,32.49)
  BOTTOM w0.089: v1(191.11,32.49) 191.11,32.77 190.86,33.02 190.1,33.02 189.32,33.8 ODD1.16
SATA_ODD_PRSNT#_R: length 4.2
  TOP w0.089: AFTP6005.1 186.06,38.15 v1(185.6,38.6) 185.6,38.91 184.64,39.88 R6004.2
  BOTTOM w0.089: ODD1.7 185.9,38.3 v1(185.6,38.6)
SD_RCOMP: length 5
  TOP w0.127: v1(110.83,86.52) 112.96,86.52 113.14,86.7 v2(113.14,87) 113.09,87.05 R1901.1
  BOTTOM w0.127: v1(110.83,86.52) 110.74,86.44 CPU1.CK33 CPU1.CM34
SD_READ_MODE#: length 152.5
  TOP w0.089: v1(201.37,37.82) 201.35,37.8 R6601.1 ; v1(165.53,41.64) 164.99,41.64 AFTP6610.1
  L5 w0.089: v1(165.53,41.64) 166.85,42.96 168.02,42.96 168.02,42.96 168.31,42.96 168.76,42.96 168.8,42.96 169.85,42.96 170.76,43.87 170.76,44.65 170.76,52.81 170.66,52.91 168.84,54.73 168.84,58.16 166.93,60.07 159.03,60.07 157.2,58.23 157.2,57.99 156.95,57.74 128.39,57.74 120.75,65.39 120.75,66.16 109.35,77.56 109.35,84.34 107.67,86.02 107.67,87.2 107.01,87.86 v1(106.28,87.86)
  L6 w0.089: v1(201.37,37.82) 200.95,38.25 200.71,38.25 200.7,38.25 199.36,38.25 198.76,37.65 198.76,35.87 197.53,34.65 192.24,34.65 192,34.88 188.68,34.88 186.44,32.65 167.45,32.65 v1(166.31,33.78)
  BOTTOM w0.089: v1(166.31,33.78) 166.31,34.46 166.17,34.6 166.17,39.89 165.74,40.32 165.74,41.44 v1(165.53,41.64) ; v1(106.28,87.86) 105.99,88.15 CPU1.CA30
SD_READ_MODE#_R: length 2.5
  TOP w0.089: v2(202.69,38.37) v1(202.05,37.82) 202.21,37.66 R6601.2
  BOTTOM w0.089: IOBD1.3 202.3,38.07 v1(202.05,37.82)
SIO_EXT_SMI#: length 10.8
  BOTTOM w0.076: CPU1.CP7 114.19,102.74 114.25,102.8
  BOTTOM w0.089: 114.25,102.8 115.72,102.8 115.93,103 117.1,103 117.6,103.5 119.97,103.5 v2(121.54,101.93) 122.43,101.04 R407.1
SIO_EXT_WAKE#: length 222.4
  TOP w0.089: U2401.116 29.96,71.3 v1(29.92,71.27) ; v1(29.06,27.23) 32.59,30.76 32.59,33.41 34.74,35.56 36.56,37.38 36.56,37.77 39.44,40.64 42.09,40.64 42.78,41.33 48.47,41.33 50.51,43.37 50.51,50.18 56.47,56.14 98.25,56.14 98.5,55.88 108.89,55.88 124.44,71.43 124.44,89.57 122.56,91.45 122.56,93.6 119.21,96.95 119.21,99.01 v1(118.52,99.7)
  L5 w0.089: v1(29.92,71.27) 28.1,71.27 27.11,70.29 27.11,69.07 24,65.96 24,63.74 22.68,62.42 22.1,62.42 16.27,56.58 16.27,50.11 16.57,49.8 16.89,49.49 16.89,36.14 17.37,35.66 17.37,32.42 20.81,28.98 20.81,28.71 23.11,26.41 23.64,26.41 24.91,27.68 25.81,27.68 25.81,27.68 26.16,27.68 26.16,27.68 28.61,27.68 v1(29.06,27.23)
  BOTTOM w0.076: 115.17,98.6 114.7,98.6 114.16,99.15 113.78,99.15 113.77,99.14 113.35,99.14 113.31,99.18 113.28,99.2 113.11,99.29 112.62,99.29 CPU1.CN12
  BOTTOM w0.089: 115.17,98.6 117.45,98.6 v2(117.81,98.96) 118.49,99.65 118.49,99.67 v1(118.52,99.7) 118.52,99.67 118.7,99.49 R2041.2
SIO_PWRBTN#: length 169.6
  TOP w0.089: U2401.52 32.75,59.91 v1(32.52,60.15) ; v1(103.53,89.13) 103.97,88.7 TP1706.1 ; v1(122.47,79.31) 122.87,79.31 123.74,78.44 123.74,71.72 108.6,56.58 98.82,56.58 98.57,56.83 56.1,56.83 49.76,50.5 49.76,47.47 48.83,46.54 48.83,44.78 46.08,42.03 42.49,42.03 41.8,41.34 37.79,41.34 v1(37.44,41)
  L3 w0.089: v1(103.53,89.13) 103.97,88.7 103.97,86.74 105.01,85.7 105.92,85.7 107.11,84.51 108.18,84.51 108.5,84.82 114.18,84.82 116.97,82.04 116.97,79.37 118.03,78.31 118.19,78.31 118.19,78.31 119.97,78.31 120.7,79.04 120.98,79.31 v1(122.47,79.31)
  BOTTOM w0.089: v1(32.52,60.15) 32.67,60 32.67,57.46 32.92,57.2 32.92,56.31 29.98,53.37 29.98,48.08 30.45,47.61 30.45,45.97 30.1,45.61 30.1,45.39 29.77,45.07 29.77,43.96 30.13,43.6 30.13,42.16 31.3,41 v1(37.44,41) ; v1(103.53,89.13) 103.21,89.45 CPU1.BU28
SIO_RCIN#: length 96
  TOP w0.089: R1820.2 152.87,68.5 155.25,66.12 155.25,65.27 159.69,60.82 v2(160.57,60.82) 162.55,58.84 v1(162.55,58.18)
  L6 w0.089: v1(162.55,58.18) 161.94,58.18 161.48,58.64 158.38,58.64 158.22,58.47 158.22,58.01 158.26,57.96 158.26,57.75 157.78,57.27 129.15,57.27 116.64,69.79 116.64,71.1 108.46,79.27 108.46,83.08 105.42,86.12 105.24,86.12 104.91,86.46 104.91,88.05 v1(104.43,88.52)
  BOTTOM w0.089: v1(104.43,88.52) CPU1.BV29
SIO_SLP_A#: length 6.4
  BOTTOM w0.089: CPU1.BU37 103.17,83.49 104,82.67 104,81.12 105.11,80.01 105.11,78.42 TP1705.1
SIO_SLP_S0#: length 218.5
  TOP w0.089: R4040.1 90.45,40.74 v2(91.29,40.74) 91.29,40.36 v1(91.04,40.11) ; v1(169.68,64.7) 170.08,65.1 170.12,65.1 170.6,65.58 170.6,68.01 170.13,68.49 170.13,70.53 168.86,71.8 168.86,73.48 168.59,73.75 168.59,74.29 168.53,74.35 168.53,77.52 168.74,77.73 168.74,79.86 168.28,80.31 R9121.2 166.98,80.01 R1739.1
  L5 w0.089: v1(169.68,64.7) 169.68,62.88 169.85,62.71 169.85,62.03 172.98,58.9 172.98,55.51 174.32,54.17 174.32,51.97 174.81,51.49 174.81,51.41 175.68,50.54 175.68,49.1 174.76,48.19 173.95,48.19 172.67,46.91 172.67,44.2 172.6,44.13 172.6,43.65 170.54,41.6 170.41,41.6 170.41,41.6 169.89,41.6 169.33,41.6 169.01,41.28 169.01,41.28 167.11,39.38 162.46,39.38 159.92,41.91 149.99,41.91 149.32,41.24 141.61,41.24 140.77,42.09 132.54,42.09 132.17,42.46 129.61,42.46 127.31,44.75 111.29,44.75 110.05,43.51 105.87,43.51 105.46,43.11 104.43,43.11 103.59,42.27 103.59,41.76 103.76,41.6 103.76,41.16 103.2,40.6 101.42,40.6 101.19,40.38 93.58,40.38 92.86,39.67 91.37,39.67 91.04,40.01 v1(91.04,40.11)
  BOTTOM w0.089: CPU1.BJ37 99.27,82.73 99.27,81.5 100.04,80.73 100.16,80.73 101.08,79.8 101.08,76.98 101.19,76.87 112.48,65.58 123.32,65.58 123.66,65.93 124.07,66.33 125.7,66.33 126.04,65.99 126.04,65.41 126.35,65.1 127.12,65.1 128.11,66.08 153.63,66.08 154.46,65.25 169.09,65.25 169.65,64.7 v1(169.68,64.7)
SIO_SLP_S3#: length 509.3
  TOP w0.089: v1(48.29,131.93) 48.01,131.93 47.86,132.08 U4001.3 ; C1703.1 87.3,40.99 v2(87.38,41.06) 87.7,41.06 87.96,40.79 R4017.1 87.95,40.17 87.95,39.78 87.85,39.68 87.35,39.68 87.08,39.4 87.08,38.83 v1(87.38,38.53)
  L5 w0.089: v1(138.94,33.83) 139.47,34.36 147.65,34.36 148.2,33.81 150.39,33.81 151.14,34.55 156.92,34.55 156.93,34.54 162.51,34.54 162.62,34.42 168.87,34.42 v1(169.51,33.78) ; v1(57.28,38) 58.35,39.07 59.69,39.07 60.53,38.22 62.62,38.22 64.14,36.7 76.58,36.7 76.7,36.83 82.32,36.83 83.01,37.52 86.36,37.52 v1(87.38,38.53) 87.38,38.35 88.31,37.42 93.15,37.42 94.15,38.43 96.2,38.43 96.28,38.35 96.29,38.35 97.59,37.05 101.19,37.05 102.16,38.02 103.63,38.02 103.76,38.15 104.65,38.15 105.2,37.6 v1(105.2,37.55)
  L6 w0.089: v1(170.83,64.8) 171.03,64.99 175.34,64.99 176.39,63.94 176.39,58.42 177.47,57.33 177.47,55.74 177.26,55.53 177.26,45.68 177.26,45.68 177.26,40.29 171.18,34.21 169.94,34.21 v1(169.51,33.78) ; v1(48.29,131.93) 46.36,130 46.36,127.69 41.02,122.36 40.72,122.36 38.71,120.35 38.71,118.75 38.14,118.18 34.56,118.18 34.16,117.77 32.67,117.77 32.61,117.83 32.45,117.83 30.08,117.83 29.09,116.84 29.09,115.29 26.57,112.78 25.23,112.78 23.43,110.97 23.43,108.36 24.07,107.72 24.31,107.72 25.38,106.65 25.38,100.12 26.34,99.16 35.24,99.16 37.16,97.24 37.16,95.04 37.24,94.96 37.67,94.54 37.71,94.5 40.13,94.5 42.42,92.21 42.42,76.71 42.07,76.36 41.53,76.36 41.28,76.11 41.28,75.58 38.69,72.98 29.6,72.98 29.49,72.88 28.14,71.52 25.65,71.52 20.71,66.58 20.71,65.89 20.81,65.78 20.81,65.78 21.24,65.36 21.24,61.3 18.93,58.99 18.93,58.85 18.93,37.05 20.53,35.45 20.53,27.33 22.78,25.07 37.3,25.07 41.51,29.29 89.29,29.29 90.85,30.85 104.97,30.85 v1(107.19,33.07) 107.88,33.07 111.06,36.26 111.06,36.53 111.41,36.88 111.41,40.76 112.91,42.27 123.72,42.27 127.89,38.1 128.72,38.1 129.33,37.49 137.54,37.49 139.68,35.35 139.68,34.57 v1(138.94,33.83)
  BOTTOM w0.089: v1(107.19,33.07) 105.63,34.64 105.63,36.29 105.08,36.84 105.08,36.87 105.08,37.43 v1(105.2,37.55) ; CPU1.BU36 102.9,84.23 102.9,83.29 103.82,82.37 103.82,81.05 104.89,79.98 104.89,77.07 111.55,70.41 115.21,70.41 115.22,70.41 115.69,70.41 118.3,67.79 127.84,67.79 128.55,67.08 169.45,67.08 170.83,65.7 v1(170.83,64.8) ; v1(87.38,38.53) 87.38,40.01 87.61,40.23 D4003.K 88.37,39.55 U4007.1 ; U4004.5 58.09,38.25 58.05,38.21 57.49,38.21 v1(57.28,38) 57.28,37.79 57.71,37.36 58.11,37.36 58.19,37.45 U4004.3
SIO_SLP_S4#: length 267.7
  TOP w0.089: v1(96.84,32.69) 97.16,32.69 97.67,33.2 PR5117.2 ; v1(115.22,113.56) 115.29,113.49 121.47,113.49 122.13,112.82 123.71,112.82 124.18,112.35 124.18,111.86 v1(124.11,111.79) ; C1702.1 104.09,90.4 v1(103.51,89.82) ; v1(173.47,68.71) 172.51,67.75 172.51,62.4 v1(172.17,62.05) ; Q9202.G 163.26,73.51 161.79,72.05 161.79,70.75 162.16,70.38 162.19,70.38 v1(162.92,69.65)
  L3 w0.089: v1(158.88,36.27) 159.34,36.73 162.93,36.73 163.36,36.3 165.46,36.3 166.09,36.93 169.7,36.93 169.83,36.81 v1(170.23,36.81) ; v1(103.51,89.82) 103.51,89.71 103.06,89.27 103.06,86.65 102.94,86.52 102.94,86.17 103.19,85.92 104.48,85.92 104.88,85.52 105.72,85.52 106.91,84.33 108.38,84.33 108.7,84.65 114.11,84.65 116.79,81.96 116.79,79.3 117.96,78.13 118.1,78.13 118.11,78.13 118.26,78.13 120.05,78.13 120.91,79 122.15,79 122.38,78.77 v1(122.81,78.77)
  L6 w0.089: v1(158.88,36.27) 158.52,35.92 158.04,35.92 156.75,34.62 149.08,34.62 149.07,34.63 148.87,34.63 147.32,36.18 145.74,36.18 142.78,39.14 130.03,39.14 129.42,39.75 128.45,39.75 124.5,43.7 112.39,43.7 108.87,40.18 108.46,40.18 106.51,38.23 106.51,35.26 103.74,32.49 97.02,32.49 96.85,32.66 96.85,32.68 v1(96.84,32.69) ; v1(170.23,36.81) 170.69,37.26 171.42,37.26 174.85,40.7 174.85,41.2 174.82,41.23 174.82,45.68 175.39,46.25 175.39,47.73 174.25,48.87 174.25,53.81 173.52,54.55 173.52,60.06 172.17,61.41 v1(172.17,62.05) ; v1(124.11,111.79) 124.11,111.57 126.34,109.34 126.34,105.03 126.9,104.48 126.9,100.74 127.58,100.06 127.58,97.23 127.02,96.67 127.02,96.02 127.31,95.73 127.31,85.09 127.91,84.49 127.91,80.51 v1(127.51,80.11) 127.09,79.69 127.09,74.68 128.66,73.1 129.9,73.1 131.81,71.19 159.75,71.19 160.38,70.56 162,70.56 v1(162.92,69.65) 163.17,69.39 171.48,69.39 171.99,68.89 173.29,68.89 v1(173.47,68.71)
  BOTTOM w0.089: v2(115.88,116) 115.83,115.95 R4024.1 114.71,115.75 114.71,114.07 v1(115.22,113.56) ; v1(122.81,78.77) 124.29,78.77 125.05,78 126.57,78 127.09,78.53 127.09,79.69 v1(127.51,80.11) ; CPU1.BU27 103.22,90.1 v1(103.51,89.82)
SIO_SLP_S5#: length 1.2
  TOP w0.089: TP1702.1 102.72,88.44 v1(102.6,88.44)
  BOTTOM w0.089: v1(102.6,88.44) 102.54,88.44 102.19,88.8 CPU1.BT29
SKTOCC#: length 3.6
  TOP w0.089: v1(71.61,107.44) 71.33,107.16 TP619.1
  BOTTOM w0.089: v1(71.61,107.44) 71.29,107.13 71.29,106.75 71.14,106.6 CPU1.E1
SLEEVE_R: length 17.1
  TOP w1.016: HPMIC1.4 4.82,21.31 15.97,21.31 ED2912.1 16.79,20.15 v2(16.79,18.91) R2911.2
SM_DRAMRST#_CPU: length 134
  TOP w0.114: R505.2 R504.1 135,42.83 135.49,43.31 135.49,43.84 135.87,44.22 v1(135.87,44.35) 136.17,43.89 136.17,43.89 v2(136.17,43.88)
  L5 w0.114: v1(103.53,87.82) 103.09,87.38 103.09,87.01 103.33,86.77 103.57,86.77 107.14,83.21 107.14,78.39 119.26,66.27 119.26,65.5 128.18,56.57 162.97,56.57 164.29,57.89 166.22,57.89 167.26,56.86 167.26,53.92 169.82,51.36 169.82,44.26 169.46,43.9 169.09,43.9 169.09,43.9 168.41,43.9 168.41,43.9 167.98,43.9 167.98,43.9 136.32,43.9 v1(135.87,44.35)
  BOTTOM w0.114: v1(103.53,87.82) 103.52,87.81 103.48,87.81 103.17,87.5 CPU1.BU31
SM_INTRUDER#: length 82.4
  TOP w0.089: v1(170.18,65.76) 170.18,66.94 R1730.2
  BOTTOM w0.089: CPU1.BR35 101.65,84.85 101.65,83.05 102.68,82.02 103.33,82.02 v2(103.41,81.94) 103.41,81.18 104.71,79.87 104.71,76.99 111.48,70.23 115.29,70.23 115.29,70.23 115.61,70.23 118.23,67.62 124.61,67.62 127.77,67.62 128.49,66.89 169.09,66.89 170.18,65.81 v1(170.18,65.76)
SM_PGCNTL: length 80.9
  TOP w0.089: v2(74.58,72.09) 74.58,72.62 v1(74.55,72.65)
  L3 w0.089: v1(74.55,72.65) 74.72,72.47 74.72,70.92 94.85,50.79 95.18,50.79 95.97,50.01 95.99,50.01 96.65,49.35 96.65,48.69 97.1,48.24 97.1,45.8 97.37,45.54 97.37,45.03 97.62,44.78 97.62,43.94 95.56,41.89 94.45,41.89 94.19,41.63 94.19,41.1 94.8,40.49 98.91,40.49 100.41,41.99 101.48,41.99 101.86,41.61 101.86,40.44 102.3,40 v1(104,40)
  BOTTOM w0.089: v1(74.55,72.65) 74.43,72.77 70.61,72.77 68.33,75.04 68.33,76.27 67.62,76.98 67.62,80.58 69.88,82.83 71.12,82.83 71.83,83.54 71.96,83.54 72.15,83.74 72.15,83.99 72.09,84.05 72.09,84.65 71.9,84.84 71.64,84.84 71.3,84.51 71.07,84.51 71,84.44 70.69,84.44 70.2,84.92 CPU1.C35 ; v1(104,40) 104,39.28 103.45,38.73 Q501.G
SM_PGCNTL_Q: length 21.6
  TOP w0.089: R507.2 108.87,30.18 109.62,30.93 v2(109.62,31.34) v1(109.62,31.93)
  BOTTOM w0.089: PU5102.5 115.5,27.79 114.75,27.04 111.22,27.04 109.62,28.64 v1(109.62,31.93) 109.62,31.99 108.57,33.04 108.57,37.53 108.28,37.82 108.28,38.86 107.47,39.68 Q502.D
SM_RCOMP_0: length 2.7
  TOP w0.203: R501.1 100.32,90.03 100.32,89.5 100.31,89.49 v2(100.31,89.48) 100.62,89.17 v1(100.78,89.17)
  BOTTOM w0.305: CPU1.BN28 100.37,89.44 100.54,89.27 100.66,89.27 v1(100.78,89.17)
SM_RCOMP_1: length 1.6
  TOP w0.203: R502.1 100.78,90.33 v1(100.78,89.81)
  BOTTOM w0.305: v1(100.78,89.81) 100.72,89.87 CPU1.BN27
SM_RCOMP_2: length 3.8
  TOP w0.203: R503.1 101.29,90.6 101.29,89.51 101.29,89.51 101.29,89.01 v1(100.82,88.54) 100.75,88.54 v2(100.2,87.99)
  BOTTOM w0.305: CPU1.BN29 100.8,88.55 100.81,88.55 v1(100.82,88.54)
SMB_ALERT#: length 10.4
  TOP w0.114: v2(117.33,97.28) 117.68,97.64 v1(118.04,97.64)
  L3 w0.089: v1(118.04,97.64) 117.84,97.64 117.5,97.98 114.24,97.98 113.13,96.88 v1(110.65,96.88)
  BOTTOM w0.114: CPU1.CJ15 110.65,97.12 v1(110.65,96.88) ; R1551.2 118.45,97.67 118.07,97.67 v1(118.04,97.64)
SMBC_THERM_NV: length 21.2
  TOP w0.114: v1(137.08,123.19) v2(137.08,123.75)
  L3 w0.089: v1(137.08,123.19) 137.08,122.56 137.44,122.19 139.88,122.19 147.34,114.73 147.85,114.73 148.87,113.71 v1(148.87,112.84)
  BOTTOM w0.114: Q7901.4 149.36,111.8 149.1,112.07 148.96,112.07 RN7901.2 v1(148.87,112.84) ; GPU1.D9 v1(137.08,123.19)
