# Allegro board 18750-1.1227WZS1652.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
KSI4: length 94.4
  TOP w0.102: U2401.104 34.75,71.82 34.07,71.14 33.79,71.14 v1(33.44,70.78) ; RN2404.6 59.33,31.78 58.58,32.54 v1(58.58,33) 58.55,33.02 58.55,34.5 AFTP6544.1
  L3 w0.102: v1(33.44,70.78) 33.13,71.09 32.66,71.09 32.31,70.74 32.31,69.39 31.93,69.01 31.93,68.38 30.46,66.9 30.46,60.3 27.24,57.09 27.24,54.79 25.58,53.13 25.58,52.06 22.88,49.36 22.88,37.37 24.11,36.15 24.11,33.09 26.32,30.88 26.32,30.63 26.98,29.97 31.05,29.97 31.69,30.61 56.19,30.61 v1(58.58,33)
  BOTTOM w0.102: KB1.27 56.72,35.05 57.03,34.75 57.43,34.75 58.55,33.63 58.55,33.02 v1(58.58,33)
KSI5: length 91.7
  TOP w0.102: AFTP6546.1 v1(59.49,33.2) 59.49,32.72 60.81,31.4 RN2403.8 ; U2401.105 34.35,71.9 34.13,71.68 34,71.68 v1(33.89,71.57)
  L3 w0.102: v1(59.49,33.2) 59.49,33.71 59.16,34.04 56.75,34.04 56.47,33.76 56.47,32.65 55.06,31.24 31.45,31.24 30.78,30.58 27.23,30.58 26.93,30.88 26.93,31.13 24.72,33.34 24.72,36.4 24.26,36.86 24.26,49.81 28.07,53.62 28.07,53.78 28.07,56.97 31.07,59.97 31.07,66.26 32.7,67.9 32.87,67.9 34.07,69.1 34.07,71.38 v1(33.89,71.57)
  BOTTOM w0.102: KB1.25 58.32,34.93 59.49,33.76 v1(59.49,33.2)
KSI6: length 89.2
  TOP w0.102: v1(58.09,33.48) 58.09,31.27 AFTP6543.1 58.83,30.22 RN2404.7 ; U2401.107 33.55,71.85 33.45,71.75 33.45,71.4 33.19,71.14 33.18,71.14 32.82,70.77 v1(32.82,70.64)
  L3 w0.102: v1(58.09,33.48) 58.09,33.17 55.76,30.84 31.63,30.84 30.97,30.17 27.06,30.17 26.52,30.72 26.52,30.97 24.31,33.18 24.31,36.23 23.85,36.69 23.85,49.97 25.78,51.9 25.78,53.05 27.45,54.71 27.45,56.99 30.66,60.2 30.66,66.8 32.13,68.28 32.13,68.93 32.82,69.61 v1(32.82,70.64)
  BOTTOM w0.102: v1(58.09,33.48) 57.1,34.47 56.37,34.47 55.92,34.91 KB1.28
KSI7: length 90.7
  TOP w0.102: v1(33.01,71.57) 33.15,71.71 U2401.108 ; v1(57.48,33.28) 57.48,30.56 58.25,29.8 RN2404.8 57.51,29.74 AFTP6542.1
  L3 w0.102: v1(33.01,71.57) 33.26,71.57 33.87,70.96 33.87,70.34 32.34,68.81 32.34,68.17 30.86,66.7 30.86,60.1 27.87,57.1 27.87,53.7 24.06,49.89 24.06,36.77 24.51,36.32 24.51,33.26 26.72,31.05 26.72,30.8 27.15,30.37 30.87,30.37 31.53,31.04 55.68,31.04 57.48,32.84 v1(57.48,33.28)
  BOTTOM w0.102: v1(57.48,33.28) 57.48,33.76 57.05,34.19 55.98,34.19 55.12,35.05 KB1.29
KSO0: length 117.1
  TOP w0.102: v1(26.5,69.8) 26.5,70.36 24.92,71.93 24.91,71.93 24.75,72.09 U2401.2 ; RN2410.5 71.71,30.15 72.72,31.17 AFTP6557.1 73.08,33.02 v1(72.37,33.73)
  L3 w0.102: v1(26.5,69.8) 25.58,68.89 25.58,67.54 24.74,66.7 24.74,66.34 25.07,66.02 25.1,66.02 25.38,65.74 25.38,64.29 25.91,63.76 25.91,61.55 25.28,60.91 25.28,60.77 25.01,60.5 23.81,60.5 23.17,59.87 23.17,58.97 20.13,55.93 20.13,49.47 20.4,49.2 20.4,43.21 19.36,42.17 19.36,36.79 20.27,35.88 20.27,29.7 22.23,27.74 22.99,27.74 23.02,27.71 32.23,27.71 32.76,28.24 38.24,28.24 38.89,27.58 66.22,27.58 v1(72.37,33.73)
  BOTTOM w0.102: v1(72.37,33.73) 71.91,33.28 68.18,33.28 67.92,33.53 KB1.13
KSO1: length 99.3
  TOP w0.102: RN2412.8 67.47,30.1 68.28,30.91 AFTP6558.1 68.28,32.23 v1(66.81,33.71) ; v1(26.12,66.75) 25.57,67.29 U2401.14
  L3 w0.102: v1(26.12,66.75) 26.07,66.7 26.07,64.44 26.53,63.98 26.53,60.39 26.05,59.91 25.63,59.91 24.66,58.93 24.02,58.93 22.48,57.39 22.48,56.26 22.37,56.15 22.37,53.89 21.66,53.18 21.66,51.25 21.06,50.65 21.06,41.55 20.68,41.17 20.68,29.87 22.4,28.14 23.16,28.14 23.17,28.14 32.05,28.14 32.56,28.65 38.45,28.65 39.11,27.99 61.09,27.99 v1(66.81,33.71)
  BOTTOM w0.102: v1(66.81,33.71) 66.81,34.62 66.32,35.11 KB1.15
KSO2: length 101.8
  TOP w0.102: U2401.15 24.81,66.89 v1(25.17,66.52) ; v1(67.47,33.71) 67.65,33.71 68.34,33.02 AFTP6556.1 69.5,31.67 68.05,30.23 RN2412.7
  L3 w0.102: v1(67.47,33.71) 61.54,27.79 38.99,27.79 38.34,28.44 32.66,28.44 32.13,27.91 23.11,27.91 23.08,27.94 22.32,27.94 20.48,29.78 20.48,35.96 19.56,36.88 19.56,42.01 20.65,43.1 20.65,49.28 20.33,49.6 20.33,55.85 23.38,58.9 23.38,59.79 23.89,60.3 25.89,60.3 26.14,60.55 26.14,63.81 25.58,64.37 25.58,66.11 v1(25.17,66.52)
  BOTTOM w0.102: KB1.14 67.12,34.08 67.47,33.73 v1(67.47,33.71)
KSO3: length 98
  TOP w0.102: v1(66.17,33.72) 67.1,32.79 AFTP6555.1 67.21,31.4 66.6,30.79 RN2409.5 ; v1(26.5,66.24) 26.36,66.09 24.97,66.09 24.57,66.49 U2401.16
  L3 w0.102: v1(66.17,33.72) 60.64,28.19 39.2,28.19 38.54,28.85 32.46,28.85 31.95,28.34 23.25,28.34 23.24,28.35 22.48,28.35 20.88,29.95 20.88,40.87 21.26,41.24 21.26,50.56 21.86,51.17 21.86,53.09 22.58,53.81 22.58,55.97 22.69,56.08 22.69,57.3 23.01,57.63 23.65,57.63 25.72,59.7 26.13,59.7 26.81,60.38 26.81,65.93 v1(26.5,66.24)
  BOTTOM w0.102: v1(66.17,33.72) 66.17,34.47 65.52,35.12 KB1.16
KSO4: length 86.2
  TOP w0.102: RN2407.3 64.06,30.89 AFTP6551.1 63.88,32.31 v1(62.51,33.68) ; v1(27.56,61.04) 26.75,60.23 U2401.37
  L3 w0.102: v1(27.56,61.04) 28.19,60.41 28.19,59.5 25.99,57.29 25.99,56.41 25.73,56.16 25.39,56.16 23.39,54.17 23.39,53.42 22.68,52.71 22.68,50.79 22.07,50.19 22.07,40.91 21.69,40.53 21.69,30.29 22.82,29.16 23.58,29.16 23.59,29.16 31.54,29.16 32.18,29.8 58.63,29.8 v1(62.51,33.68)
  BOTTOM w0.102: KB1.20 62.32,33.87 v1(62.51,33.68)
KSO5: length 87.9
  TOP w0.102: U2401.38 27.15,59.34 27.12,59.37 27.12,59.96 v1(27.56,60.4) ; v1(61.8,33.68) 62.69,32.79 AFTP6549.1 63.41,32.25 RN2407.4
  L3 w0.102: v1(27.56,60.4) 27.99,59.97 27.99,59.58 27.49,59.08 26.42,59.08 25.02,57.69 25.02,56.22 23.19,54.39 23.19,53.5 22.47,52.79 22.47,50.91 21.87,50.31 21.87,40.99 21.49,40.61 21.49,30.2 22.74,28.96 23.5,28.96 23.5,28.95 31.65,28.95 32.29,29.59 59.03,29.59 62.94,33.5 62.94,33.86 62.69,34.11 62.23,34.11 v1(61.8,33.68)
  BOTTOM w0.102: KB1.21 61.52,33.96 v1(61.8,33.68)
KSO6: length 87.5
  TOP w0.102: AFTP6553.1 64.9,34.44 v1(64.9,33.73) 64.9,33.55 65.51,32.94 RN2409.7 ; U2401.39 v1(27.55,59.76)
  L3 w0.102: v1(27.55,59.76) 27.09,59.3 26.23,59.3 23.09,56.16 23.09,55.91 22.98,55.8 22.98,53.64 22.27,52.92 22.27,51 21.67,50.39 21.67,41.08 21.29,40.7 21.29,30.12 22.65,28.75 23.41,28.75 23.42,28.75 31.75,28.75 32.39,29.39 60.56,29.39 v1(64.9,33.73)
  BOTTOM w0.102: v1(64.9,33.73) 64.9,34.06 63.92,35.04 KB1.18
KSO7: length 95.7
  TOP w0.102: v1(64.27,33.73) 64.27,33.43 AFTP6552.1 65.05,30.71 64.93,30.58 RN2409.8 ; U2401.50 31.95,62.08 29.9,64.14 v1(29.59,64.14)
  L3 w0.102: v1(29.59,64.14) 29.04,63.58 29.04,60.05 26.19,57.21 26.19,56.33 25.82,55.96 25.47,55.96 23.59,54.08 23.59,53.33 22.88,52.62 22.88,50.7 22.28,50.1 22.28,40.82 21.9,40.45 21.9,30.37 22.91,29.36 23.67,29.36 23.67,29.36 31.44,29.36 32.08,30 57.87,30 61.37,33.5 61.37,33.86 61.83,34.32 63.68,34.32 v1(64.27,33.73)
  BOTTOM w0.102: v1(64.27,33.73) 64.27,33.81 63.12,34.95 KB1.19
KSO8: length 94.9
  TOP w0.102: v1(65.54,33.74) 66.25,33.02 AFTP6554.1 66.01,30.91 RN2409.6 ; v1(27.64,63.02) 30.36,60.3 U2401.46
  L3 w0.102: v1(65.54,33.74) 60.99,29.19 32.49,29.19 31.85,28.55 23.33,28.55 23.33,28.55 22.57,28.55 21.09,30.03 21.09,40.78 21.46,41.16 21.46,50.48 22.07,51.08 22.07,53.01 22.78,53.72 22.78,55.88 22.89,55.99 22.89,56.25 26.14,59.5 26.22,59.5 27.04,60.32 27.04,62.42 v1(27.64,63.02)
  BOTTOM w0.102: KB1.17 64.72,35.08 65.54,34.27 v1(65.54,33.74)
KSO9: length 91.9
  TOP w0.102: v1(36.17,62) 36.31,62 37.02,61.29 U2401.68 ; R2450.1 73.7,30.7 73.7,32.31 AFTP6563.1 v1(73.08,33.73) 73.05,33.76 R2449.2
  L3 w0.102: v1(73.08,33.73) 71.61,35.21 64.86,35.21 64.41,35.66 55.58,35.66 52.81,32.89 27.83,32.89 27.36,33.37 27.36,39.47 25.92,40.91 25.92,49.16 30.43,53.68 30.43,56.26 v1(36.17,62)
  BOTTOM w0.102: v1(73.08,33.73) 73.08,33.83 72.72,34.19 KB1.7
KSO10: length 94.2
  TOP w0.102: RN2411.3 75.16,29.8 75.42,29.54 AFTP6566.1 75.97,32.26 v1(74.53,33.71) ; v1(37.32,63.09) 37.52,62.89 U2401.72
  L3 w0.102: v1(37.32,63.09) 37.32,62.72 36.81,62.21 36.81,61.74 36.44,61.37 36.19,61.37 30.84,56.02 30.84,53.51 26.33,49 26.33,42.1 28.28,40.15 28.28,39.63 27.77,39.12 27.77,33.54 28,33.3 52.64,33.3 55.41,36.07 64.58,36.07 65.01,35.64 72.6,35.64 v1(74.53,33.71)
  BOTTOM w0.102: v1(74.53,33.71) 74.53,34.47 74.32,34.68 KB1.5
KSO11: length 92.7
  TOP w0.102: U2401.74 38.39,63.69 38.3,63.78 37.26,63.78 36.71,63.22 36.71,63.14 36.68,63.12 v1(36.68,63.09) ; RN2411.4 73.9,30.26 74.83,31.19 AFTP6565.1 75.01,32.49 v1(73.79,33.71)
  L3 w0.102: v1(73.79,33.71) 72.09,35.41 64.95,35.41 64.49,35.87 55.49,35.87 52.72,33.1 27.92,33.1 27.56,33.45 27.56,39.56 26.12,41 26.12,49.08 30.64,53.59 30.64,56.1 36.11,61.57 36.35,61.57 36.6,61.82 36.6,63.02 v1(36.68,63.09)
  BOTTOM w0.102: v1(73.79,33.71) 73.79,34.46 73.52,34.73 KB1.6
KSO12: length 94.3
  TOP w0.102: AFTP6559.1 68.35,34.52 v1(68.35,33.71) 68.51,33.71 68.91,33.3 69.52,33.3 69.98,32.84 69.98,31.52 68.55,30.1 RN2412.6 ; v1(35.23,64.85) 35.31,64.77 35.74,64.77 36.42,64.09 U2401.75
  L3 w0.102: v1(68.35,33.71) 67.88,34.18 64.46,34.18 63.99,34.65 56,34.65 53.23,31.88 27.05,31.88 25.33,33.6 25.33,36.92 25.53,37.13 25.53,39.87 24.9,40.49 24.9,42.17 24.9,42.17 24.9,49.59 29.39,54.07 29.39,57.29 31.68,59.58 31.68,60.97 32.97,62.27 32.97,62.59 v1(35.23,64.85)
  BOTTOM w0.102: v1(68.35,33.71) 68.35,34.27 68.72,34.63 KB1.12
KSO13: length 93.5
  TOP w0.102: v1(36.38,64.87) 36.35,64.85 36.35,64.52 36.48,64.39 38.28,64.39 38.39,64.49 U2401.76 ; RN2410.7 70.62,30.29 72.06,31.73 AFTP6562.1 71.55,32.82 70.92,33.45 v1(70.92,33.76)
  L3 w0.102: v1(36.38,64.87) 36.38,64.36 33.61,61.6 33.61,60.5 30.03,56.92 30.03,53.85 25.51,49.33 25.51,40.75 26.14,40.12 26.14,36.87 25.94,36.67 25.94,33.85 27.3,32.49 52.98,32.49 55.75,35.26 64.24,35.26 64.7,34.8 69.88,34.8 v1(70.92,33.76)
  BOTTOM w0.102: KB1.9 71.12,33.96 v1(70.92,33.76)
KSO14: length 93.1
  TOP w0.102: AFTP6564.1 71.64,34.74 v1(71.64,33.73) 71.68,33.73 72.47,32.95 72.47,31.45 71.12,30.1 RN2410.6 ; v1(37.8,64.85) 37.84,64.89 U2401.77
  L3 w0.102: v1(37.8,64.85) 33.81,60.86 33.81,60.42 30.23,56.84 30.23,53.76 25.72,49.25 25.72,40.83 26.34,40.2 26.34,36.79 26.29,36.74 26.29,33.78 27.38,32.69 52.89,32.69 55.66,35.46 64.32,35.46 64.78,35 70.37,35 v1(71.64,33.73)
  BOTTOM w0.102: v1(71.64,33.73) 71.64,33.77 71.91,34.04 71.91,34.75 71.92,34.76 KB1.8
KSO15: length 96.3
  TOP w0.102: v1(35.82,66.14) 37.21,67.54 37.21,67.87 37.84,68.49 U2401.86 ; AFTP6561.1 70.16,34.52 v1(70.16,33.73) 71.3,32.59 71.3,31.3 70.03,30.03 RN2410.8
  L3 w0.102: v1(35.82,66.14) 35.82,65.46 35.87,65.41 35.87,64.43 32.08,60.65 32.08,59.41 29.8,57.13 29.8,53.9 25.31,49.42 25.31,42.34 25.31,40.66 25.94,40.03 25.94,36.96 25.73,36.76 25.73,33.77 27.21,32.28 53.06,32.28 55.83,35.05 64.15,35.05 64.61,34.6 69.29,34.6 v1(70.16,33.73)
  BOTTOM w0.102: v1(70.16,33.73) 70.32,33.89 KB1.10
KSO16: length 98.4
  TOP w0.102: v1(69.09,33.73) 69.57,33.68 70.12,32.98 70.18,32.92 70.18,32.91 70.74,32.35 AFTP6560.1 70.2,31.21 69.14,30.15 RN2412.5 ; U2401.92 38.33,70.89 37.9,71.32 37.9,71.34 v1(37.88,71.35)
  L3 w0.102: v1(69.09,33.73) 68.43,34.39 64.53,34.39 64.07,34.85 55.91,34.85 53.15,32.08 27.13,32.08 25.53,33.68 25.53,36.84 25.73,37.04 25.73,39.95 25.11,40.58 25.11,42.26 25.11,49.5 29.59,53.99 29.59,57.21 31.88,59.5 31.88,60.88 35.66,64.67 35.66,65.28 35.39,65.56 35.39,66.32 35.64,66.57 35.64,66.57 36.71,67.64 36.71,68 36.7,68.01 36.7,70.17 v1(37.88,71.35)
  BOTTOM w0.102: KB1.11 69.52,34.16 v1(69.09,33.73)
L_BKLT_CTRL: length 194.6
  TOP w0.089: v1(168.53,63.43) 168.53,62.43 v2(168.58,62.38) 169.12,61.85 169.4,61.85 169.75,61.5 173.22,61.5 173.85,62.13 173.85,63.78 173.73,63.9 173.73,66.82 174.59,67.69 174.59,70.88 173.62,71.86 173.62,72.43 173.87,72.68 174.68,72.68 176,71.36 176,70.84 180.33,66.51 180.33,63.62 183.11,60.84 187.85,60.84 191.37,64.35 191.37,65.86 191.65,66.14 210.77,66.14 211.08,65.84 214.68,65.84 215.06,65.46 215.06,64.85 215.31,64.6 216.34,64.6 v1(216.77,65.03)
  L5 w0.089: v1(109.34,100.06) 109.77,100.49 113.54,100.49 114.91,99.12 118.75,99.12 119.08,98.8 119.08,96.9 120.17,95.8 120.17,95.23 121.79,93.61 121.79,91.4 123.37,89.82 123.37,81.21 123.38,81.2 123.38,78.73 123.22,78.57 123.22,71.98 125.81,69.39 125.91,69.39 131.01,64.3 157.62,64.3 157.93,64.61 164.63,64.61 165.43,63.81 168.15,63.81 v1(168.53,63.43)
  L6 w0.089: v1(212.14,46.35) 211.17,47.33 211.17,47.82 210.92,48.07 210.82,48.07 210.16,48.73 210.16,51.82 208.79,53.18 208.79,54.59 210.01,55.81 211.41,55.81 212.26,56.65 213.94,56.65 214.66,55.93 216.56,55.93 218.8,58.17 220.17,58.17 220.93,58.93 220.93,61.37 218,64.3 217.5,64.3 v1(216.77,65.03)
  BOTTOM w0.089: CPU1.CH11 v1(109.34,100.06) ; D5503.1 211.77,46.72 v1(212.14,46.35)
L_BKLT_EN: length 358.6
  TOP w0.089: v1(171.39,59.48) 171.83,59.92 175.52,59.92 176.03,60.43 182.52,60.43 182.82,60.13 188.15,60.13 191.38,63.36 203.11,63.36 204.51,61.96 204.59,61.96 207.09,59.46 R2438.2 ; R2435.2 40.9,54.69 42.08,53.5 42.08,50.83 41.85,50.6 41.42,50.6 40.52,49.7 40.52,47.87 39.81,47.15 39.24,47.15 38.69,47.7 36.31,47.7 35.26,46.65 35.26,45.15 33.79,43.67 32.75,43.67 29.98,40.9 28.58,40.9 v1(27.71,40.03) 27.49,39.8 27.49,37.18 25.67,35.36 23.4,35.36 23.22,35.19 23.22,33.4 22.77,32.95 21.97,32.95 v1(18.84,29.82) ; v1(107.93,37.52) v2(107.93,38.13)
  L3 w0.089: v1(110.66,100.09) 110.21,100.54 107.86,100.54 107.61,100.29 107.61,98.34 v1(107.97,97.98)
  L5 w0.089: v1(110.66,100.09) 111.09,99.66 114.11,99.66 114.83,98.93 118.57,98.93 118.89,98.61 118.89,96.83 119.92,95.81 119.92,95.18 121.61,93.48 121.61,91.33 123.19,89.74 123.19,82.1 120.23,79.13 120.23,74.36 125.38,69.22 125.83,69.22 130.93,64.12 157.69,64.12 158,64.43 164.56,64.43 165.36,63.63 167.63,63.63 171.39,59.86 v1(171.39,59.48) ; v1(107.93,37.52) 108.02,37.42 108.02,36.78 106.35,35.1 103.23,35.1 101.75,33.62 98.26,33.62 97.53,34.35 96.66,34.35 82.59,34.35 82.13,33.89 81.4,33.89 80.88,34.41 54.61,34.41 52.78,32.58 35.96,32.58 35.96,32.58 35.78,32.58 30.89,27.68 30,27.68 29.75,27.43 29.75,27.01 29.52,26.78 29.52,26.32 29.37,26.16 26.72,26.16 26.43,25.88 22.89,25.88 18.94,29.82 v1(18.84,29.82)
  L6 w0.089: v1(102.87,48.06) 102.87,49.79 101.42,51.24 101.42,73.11 102.32,74.01 102.32,80.23 101.77,80.78 101.77,82.36 101.28,82.85 101.28,86.81 101.19,86.89 101.19,87.69 101.27,87.77 101.27,89.86 101.32,89.91 101.32,90.17 101.58,90.43 101.84,90.43 102.63,91.21 103.1,91.21 105.69,93.81 105.69,94.7 107.06,96.06 107.35,96.06 107.97,96.69 v1(107.97,97.98)
  BOTTOM w0.089: CPU1.CK11 110.94,100.54 v1(110.66,100.09) ; R2436.1 27.71,40.13 v1(27.71,40.03) ; v1(102.87,48.06) 103.25,47.68 103.25,47.47 105.03,45.69 105.03,45.01 105.67,44.38 105.67,41.45 106.02,41.1 106.02,38.46 106.96,37.52 v1(107.93,37.52) ; R2427.2 21.44,35.54 21.06,35.16 21.06,31.73 19.16,29.82 v1(18.84,29.82)
L_BKLT_EN_L: length 3.2
  BOTTOM w0.089: R2427.1 21.58,39.18 v2(22.36,39.18) 22.36,39.57 21.76,40.17 D2401.2
LAN_CABLE_DETECT_R_#: length 3.3
  TOP w0.089: U3101.26 47.09,85.83 47.53,86.26 v2(48.26,86.26) 49.58,86.26 49.79,86.06
LAN_CLK_CPU_N: length 90.4
  TOP w0.114: v1(48.68,77.78) 48.59,77.68 48.41,77.68 48.24,77.85 48.24,78.39 47.32,79.3 47.32,81.14 47.49,81.31 U3101.16
  L5 w0.102: v1(93.68,110.56) 93.43,110.31 93.25,110.31 92.99,110.57 92.99,111.25 87.3,116.94 66.96,116.94 61.2,111.18 58.29,111.18 56.24,109.13 56.24,101.62 54.13,99.51 54.13,96 52.68,94.55 52.68,93.6 49.69,90.6 49.69,88.69 50.42,87.96 50.42,81.94 49.23,80.75 49.23,77.55 49.1,77.42 49.02,77.42 48.68,77.75 v1(48.68,77.78)
  BOTTOM w0.114: v1(93.68,110.56) 93.96,110.56 94.08,110.43 94.08,110.14 94.59,109.63 94.59,108.86 94.91,108.54 94.91,107.1 95.09,106.93 95.09,105.7 CPU1.BD3
LAN_CLK_CPU_P: length 90.4
  TOP w0.114: U3101.15 47.09,81.23 47.09,81.23 47.09,79.21 48.01,78.29 48.01,77.76 48.31,77.45 48.37,77.45 v1(48.68,77.14)
  L5 w0.102: v1(93.68,109.92) 93.5,110.1 93.17,110.1 92.79,110.48 92.79,111.17 87.22,116.74 67.05,116.74 61.28,110.97 58.37,110.97 56.44,109.04 56.44,101.53 54.33,99.43 54.33,95.91 52.89,94.46 52.89,93.52 49.89,90.52 49.89,88.77 50.62,88.04 50.62,81.85 49.43,80.66 49.43,77.46 49.19,77.22 48.76,77.22 v1(48.68,77.14)
  BOTTOM w0.114: v1(93.68,109.92) 93.71,109.94 93.96,109.94 94.08,109.82 94.36,109.54 94.36,108.76 94.68,108.44 94.68,107.01 94.86,106.83 94.86,105.92 94.34,105.39 CPU1.BC3
LAN_LED0: length 53.5
  TOP w0.203: v1(46.84,86.29) 46.82,86.29 46.69,86.16 U3101.27
  TOP w0.254: v1(14.3,67.29) 14.3,65.94 15.73,64.52 15.73,62.84 v2(16.44,62.13) 17.05,61.52 v1(17.17,61.52) 17.78,61.52 17.85,61.46 Q3201.S
  L3 w0.254: v1(45.9,79.63) 46.23,79.96 46.23,82.04 46.61,82.42 46.61,86.06 v1(46.84,86.29)
  BOTTOM w0.254: v1(17.17,61.52) 17.3,61.65 R3203.1 ; v1(45.9,79.63) 45.84,79.63 44.89,78.68 44.89,78.67 43.09,76.86 41.02,76.86 40.39,76.23 38.23,76.23 37.61,75.61 35.43,75.61 34.31,74.49 31.54,74.49 28.38,71.32 27.89,71.32 26.88,70.31 26.28,70.31 26.21,70.23 23.49,70.23 23.13,69.88 20.42,69.88 19.12,68.58 15.6,68.58 v1(14.3,67.29)
LAN_LED0_Q: length 5.7
  TOP w0.254: v1(17.17,60.89) 17.66,60.89 17.88,60.66 17.88,60.66 Q3201.D 19.15,59.26 v2(18.14,59.26) 17.07,59.26 R3202.1
  BOTTOM w0.254: R3203.2 17.28,60.78 v1(17.17,60.89)
LAN_LED0_R: length 11.1
  TOP w0.254: R3202.2 17.02,60.28 v2(16.39,60.91) 15.17,62.13 15.17,64.02 12.74,66.45 v1(10.72,66.45)
  BOTTOM w0.254: LED2.K v1(10.72,66.45)
LAN_MDI0_N: length 10.8
  TOP w0.089: U3101.2 43.79,84.54 43.71,84.62 43.37,84.62 43.09,84.34 42.94,84.34 v1(42.87,84.26)
  BOTTOM w0.089: 39.27,86.92 39.27,85.36 39.59,85.04 39.86,85.04 39.97,84.93 ED3201.9 ED3201.2 41.42,84.93 41.55,85.06 41.69,85.06 42.3,84.46 42.68,84.46 v1(42.87,84.26) ; 39.27,86.92 v2(39.12,86.92) ; 39.27,86.92 39.27,88.21 39.18,88.3 38.78,88.3 38.7,88.21 38.7,87.89 38.61,87.8 XF3202.8
LAN_MDI0_P: length 10.6
  TOP w0.089: v1(42.87,84.9) 43.02,84.9 43.04,84.88 43.7,84.88 43.81,84.94 U3101.1
  BOTTOM w0.089: XF3202.7 38.61,89.07 38.7,88.98 38.7,88.66 38.78,88.57 39.29,88.57 39.39,88.47 ; v2(39.5,88.57) 39.39,88.47 ; 39.39,88.47 39.54,88.32 39.54,85.47 39.7,85.31 39.89,85.31 40,85.41 ED3201.10 ED3201.1 41.42,85.41 41.5,85.33 41.8,85.33 42.41,84.72 42.7,84.72 v1(42.87,84.9)
LAN_MDI1_N: length 10
  TOP w0.089: U3101.5 43.79,83.34 43.31,82.86 v1(42.92,82.86)
  BOTTOM w0.089: v2(39.86,81.51) 39.7,81.51 ; 39.7,81.51 39.7,81.15 39.24,80.68 38.78,80.68 38.7,80.59 38.7,80.27 38.61,80.18 XF3202.12 ; 39.7,81.51 39.7,83.3 39.82,83.41 ED3201.6 ED3201.5 41.45,83.41 41.55,83.51 41.92,83.51 42.37,83.06 42.72,83.06 v1(42.92,82.86)
LAN_MDI1_P: length 10.2
  TOP w0.089: v1(42.92,83.52) 43.03,83.52 43.22,83.33 43.4,83.33 43.81,83.74 U3101.4
  BOTTOM w0.089: XF3202.11 38.61,81.45 38.7,81.36 38.7,81.04 38.78,80.95 39.13,80.95 39.44,81.26 39.44,83.41 39.92,83.89 ED3201.7 ED3201.4 41.41,83.89 41.53,83.78 42.03,83.78 42.13,83.68 ; v2(42.24,83.8) 42.13,83.68 ; 42.13,83.68 42.48,83.33 42.73,83.33 v1(42.92,83.52)
LAN_MDI2_N: length 18.4
  TOP w0.089: XF3201.12 36.59,89.07 36.5,88.98 36.5,88.66 36.41,88.57 36.09,88.57 35.89,88.77 35.89,89.41 36.38,89.9 38.55,89.9 38.85,89.6 38.85,85.54 39.04,85.35 ; 39.04,85.35 39.35,85.05 39.63,85.05 39.74,84.94 ED3202.2 ED3202.9 41.84,84.94 42.08,84.7 42.08,82.45 42.36,82.17 43.31,82.17 43.67,82.54 U3101.7 ; 39.04,85.35 v2(38.94,85.24)
LAN_MDI2_P: length 19.4
  TOP w0.089: 39.12,87.66 39.12,89.71 38.66,90.17 36.27,90.17 35.63,89.52 35.63,88.66 35.98,88.3 36.39,88.3 36.48,88.21 36.48,87.89 36.57,87.8 XF3201.11 ; 39.12,87.66 39.12,85.65 39.46,85.31 39.63,85.31 39.74,85.42 ED3202.1 ED3202.10 41.74,85.42 42.34,84.81 42.34,82.56 42.47,82.44 43.2,82.44 43.7,82.94 U3101.6 ; 39.12,87.66 v2(39.27,87.66)
LAN_MDI3_N: length 20
  TOP w0.089: v2(39.4,80.42) 39.25,80.42 ; 39.25,80.42 39.25,83.27 39.5,83.53 39.63,83.53 39.74,83.42 ED3202.5 ED3202.6 41.22,83.42 41.34,83.3 41.34,81.88 42.55,80.67 44.55,80.67 45.09,81.21 U3101.10 ; 39.25,80.42 39.25,79.56 38.86,79.17 35.94,79.17 35.55,79.57 35.55,80.68 35.82,80.95 36.28,80.95 36.37,81.04 36.37,81.36 36.46,81.45 XF3201.8
LAN_MDI3_P: length 18.9
  TOP w0.089: v2(39.14,83.77) 39.26,83.66 ; 39.26,83.66 39.39,83.79 39.63,83.79 39.74,83.9 ED3202.4 ED3202.7 41.32,83.9 41.61,83.61 41.61,81.99 42.66,80.94 44.44,80.94 44.69,81.19 U3101.9 ; 39.26,83.66 38.98,83.38 38.98,79.67 38.75,79.44 36.05,79.44 35.82,79.68 35.82,80.57 35.93,80.68 36.28,80.68 36.37,80.59 36.37,80.27 36.46,80.18 XF3201.7
LAN_PCIE_RX_C_N: length 2.7
  TOP w0.114: C3107.2 48.74,80.74 48.74,82.12 48.32,82.54 U3101.18
LAN_PCIE_RX_C_P: length 2.2
  TOP w0.114: C3102.2 48.51,80.67 48.51,82.02 48.4,82.14 U3101.17
LAN_PCIE_RX_N: length 99.2
  TOP w0.114: v1(51.59,76.04) 51.59,76.05 52.03,76.49 52.03,76.51 52.26,76.74 52.26,77.61 51.86,78 50.09,78 48.95,79.15 48.95,79.41 C3107.1
  L6 w0.102: v1(51.59,76.04) 52.02,76.47 52.25,76.47 55.88,80.1 55.88,89.26 53.83,91.31 53.83,95.85 55.07,97.1 55.07,99.48 58.58,102.99 59.99,102.99 61.82,104.81 63.91,104.81 65.03,105.93 65.03,106.82 66.78,108.58 66.78,109.35 68.25,110.82 68.25,111.81 69.09,112.64 73.25,112.64 73.94,113.34 91,113.34 92.7,115.04 99.52,115.04 102.64,111.91 102.64,104.28 102.16,103.79 102.16,103.66 101.97,103.47 v1(101.93,103.47)
  BOTTOM w0.114: v1(101.93,103.47) 101.88,103.47 101.78,103.55 CPU1.BP5
LAN_PCIE_RX_P: length 99.6
  TOP w0.114: C3102.1 48.66,79.11 50,77.78 51.77,77.78 52.03,77.52 52.03,76.84 51.87,76.67 v1(51.59,76.67)
  L6 w0.102: v1(101.93,102.82) 102.37,103.25 102.37,103.71 102.85,104.19 102.85,111.99 99.6,115.24 92.61,115.24 90.92,113.54 73.86,113.54 73.16,112.84 69,112.84 68.05,111.89 68.05,110.91 66.58,109.43 66.58,108.66 64.82,106.91 64.82,106.02 63.82,105.02 61.74,105.02 59.91,103.19 58.49,103.19 54.87,99.56 54.87,97.18 53.62,95.94 53.62,91.23 55.67,89.18 55.67,80.18 52.16,76.67 v1(51.59,76.67)
  BOTTOM w0.114: v1(101.93,102.82) 101.93,102.82 101.86,102.82 101.78,102.9 CPU1.BP6
LAN_PCIE_TX_N: length 9.3
  BOTTOM w0.076: 102.2,108.87 102.2,108.85 102.18,108.83 102.18,108.14 101.99,107.95 101.99,106.5 CPU1.BR2
  BOTTOM w0.114: 102.2,108.87 102.2,112.25 100.95,113.5 C3109.1
LAN_PCIE_TX_N_C: length 99.6
  TOP w0.114: U3101.14 46.69,81.08 46.61,81 46.61,77.96 47.07,77.5 v1(47.4,77.5)
  L6 w0.102: v1(47.4,77.5) 47.72,77.18 47.91,77.18 48.03,77.3 48.03,79.22 49.33,80.52 50.37,80.52 51.54,81.69 51.54,88.16 50.6,89.1 50.6,92.45 49.26,93.79 49.26,100.07 51.49,102.29 51.49,105.15 52.53,106.19 52.53,111.33 53.29,112.09 55.44,112.09 56.12,112.78 62.1,112.78 66.95,117.63 87.35,117.63 88.72,119 90.47,119 91.06,119.58 94.46,119.58 94.72,119.85 99.49,119.85 99.8,119.53 v1(99.8,119.3)
  BOTTOM w0.114: v1(99.8,119.3) 99.57,119.07 99.57,117.48 100.93,116.12 100.93,115.37 C3109.2
LAN_PCIE_TX_P: length 9.2
  BOTTOM w0.076: CPU1.BR1 101.68,106.48 101.81,106.61 101.81,108.02 102,108.21 102,108.84 101.97,108.86 101.97,108.87
  BOTTOM w0.114: C3104.1 100.19,114.43 100.06,114.3 100.06,114.12 100.2,113.97 100.6,113.97 100.73,113.84 100.73,113.41 101.97,112.16 101.97,108.87
LAN_PCIE_TX_P_C: length 99.6
  TOP w0.114: v1(47.4,76.86) 47.4,76.89 47.21,77.08 47.17,77.08 46.38,77.86 46.38,81.03 46.29,81.12 U3101.13
  L6 w0.102: v1(99.16,119.3) 99.16,119.52 99.04,119.64 94.81,119.64 94.54,119.38 91.14,119.38 90.56,118.8 88.8,118.8 87.43,117.43 67.04,117.43 62.19,112.57 56.21,112.57 55.52,111.89 53.38,111.89 52.73,111.25 52.73,106.1 51.69,105.06 51.69,102.21 49.46,99.98 49.46,93.87 50.8,92.53 50.8,89.19 51.74,88.25 51.74,81.6 50.46,80.32 49.42,80.32 48.24,79.14 48.24,77.22 47.99,76.97 47.51,76.97 v1(47.4,76.86)
  BOTTOM w0.114: v1(99.16,119.3) 99.34,119.12 99.34,117.38 100.7,116.03 100.7,115.75 100.29,115.34 C3104.2
LAN_WAKE#: length 96.9
  TOP w0.089: v1(159.57,57.81) v2(158.27,59.11) 157.96,59.42 156.56,59.42 153.99,61.99 153.99,65.44 150.82,68.61 145.67,68.61 145.49,68.43 144.31,68.43 143.36,69.38 143.36,69.7 142.9,70.16 R1707.2
  L6 w0.089: v1(159.57,57.81) 159.57,57.61 158.63,56.67 129.18,56.67 115.94,69.9 115.94,70.55 104.12,82.38 104.12,82.48 104.02,82.58 104.02,86.59 103.8,86.81 103.8,86.89 v1(103.51,87.19)
  BOTTOM w0.089: v1(103.51,87.19) 103.47,87.15 103.44,87.15 CPU1.BU32
LANWAKE#: length 10.5
  TOP w0.089: v1(20.42,58.8) 20.42,58.7 21.59,57.53 22.25,57.53 v2(22.33,57.46) 22.53,57.46 23.05,57.98 24.32,57.98 25.22,57.08 25.66,57.08 25.95,57.37 U2401.35
  BOTTOM w0.089: R2428.2 19.1,60.12 v1(20.42,58.8)
LANXIN: length 5.3
  TOP w0.114: U3101.28 46.29,85.86 46.38,85.95 46.38,86.57 46.5,86.69 C3125.1 46.36,86.99 45.65,87.71 45.65,88.9 46.41,89.66 X3101.1
LANXOUT: length 3.8
  TOP w0.114: U3101.29 45.89,85.85 46.14,86.09 46.14,86.82 45.94,87.02 C3116.1 44.4,88.15 X3101.3
LCD_BRIGHTNESS: length 5.1
  TOP w0.089: RN5503.6 222.5,39.86 221.8,40.57 220.6,40.57 v2(220.35,40.82) 220.2,40.82 219.71,41.3 v1(219.71,41.76)
  BOTTOM w0.089: v1(219.71,41.76) 219.42,42.05 LCD1.31
LCD_CBL_DET#: length 169.1
  TOP w0.089: v1(216.79,42.37) 216.25,41.84 215.42,41.84 AFTP5517.1
  L3 w0.089: v1(123.6,91.9) 122.62,92.88 122.62,96.88 121.12,98.38 121.12,98.52 120.67,98.97 119.68,98.97 119.63,98.92 114.03,98.92 v1(113.87,98.76) ; v1(219.74,42.83) 220.53,42.83 221.1,43.4 221.1,60.88 219.86,62.13 217,62.13 216.49,62.63 v1(216.49,62.84)
  L6 w0.089: v1(128.25,92.2) 128.25,92.05 127.8,91.6 127.8,85.29 128.45,84.63 128.45,74.92 131.99,71.38 159.87,71.38 160.45,70.79 162.87,70.79 163.88,69.78 171.44,69.78 172.14,69.07 172.5,69.07 172.56,69.13 175.85,69.13 176.34,68.64 177.18,68.64 177.74,68.08 177.89,68.08 178.45,68.08 180.24,66.29 180.24,63.9 184.37,59.76 189.56,59.76 191.24,61.44 204.02,61.44 205.91,63.34 216.16,63.34 216.49,63.01 v1(216.49,62.84)
  BOTTOM w0.089: v1(123.6,91.9) 124.47,91.9 124.7,92.13 125.44,92.13 125.69,92.38 125.69,92.52 125.91,92.74 127.49,92.74 128.02,92.2 v1(128.25,92.2) ; v1(219.74,42.83) 219.51,43.05 LCD1.29 217.47,43.05 216.79,42.37 v1(216.79,42.37) 216.02,41.61 R2060.2 ; CPU1.CN14 112.66,98.65 113.77,98.65 v1(113.87,98.76)
LCD_TST: length 292.4
  TOP w0.089: v1(220.22,37.64) 220.22,37.47 v2(220.56,37.13) 220.96,37.53 220.96,38.91 221.08,39.04 221.9,39.04 222,38.94 RN5503.2 ; U2401.26 24.75,62.49 v1(24.79,62.54)
  L5 w0.089: v1(24.79,62.54) 23.72,61.47 23.72,61.15 18.39,55.82 18.39,50.3 17.78,49.68 17.78,36.51 19.01,35.27 19.01,32.04 22.42,28.63 29.27,28.63 29.33,28.69 29.78,28.69 29.78,28.69 30.55,28.69 35.33,33.47 35.36,33.47 35.4,33.51 52.45,33.51 54.24,35.3 76.18,35.3 77,36.12 83.65,36.12 84.25,36.73 93.6,36.73 94.76,37.89 95.85,37.89 96.33,37.41 96.43,37.31 96.58,37.31 97.06,36.83 97.37,36.52 101.41,36.52 102.2,37.31 103.38,37.31 103.75,36.94 105.44,36.94 105.8,37.3 105.8,37.78 107.43,39.41 107.43,41.79 108.57,42.93 110.24,42.93 111.53,44.22 126.96,44.22 129.39,41.78 130.64,41.78 130.76,41.66 130.76,40.4 131.61,39.56 136.23,39.56 138.35,41.68 140.4,41.68 141.91,40.16 151.11,40.16 151.74,40.79 157.49,40.79 158.24,40.03 158.24,39.5 158.72,39.02 167.25,39.02 169.47,41.24 171.04,41.24 v1(171.48,41.68) ; v1(220.22,37.64) 220.22,38.4 217.88,40.75 213.53,40.75 211.43,38.64 208.59,38.64 207.86,37.9 205.3,37.9 204.59,38.61 203.03,38.61 203.03,38.61 199.65,38.61 199.27,38.99 193.47,38.99 192.68,39.78 190.15,39.78 186.06,35.69 183.28,35.69 182.53,36.44 179.07,36.44 178.04,35.42 170.6,35.42 v1(170.41,35.22)
  L6 w0.089: v1(220.22,37.64) 220.22,37.59 220.45,37.36 220.45,36.07 220.2,35.82 219.5,35.82 216.85,38.47 215.76,38.47 212.47,41.76 v1(212.47,42.22)
  BOTTOM w0.089: v1(212.47,42.22) 211.66,43.03 211.36,43.03 211.14,43.24 211.14,44.03 211.2,44.09 211.2,46.08 210.85,46.43 209.83,46.43 D5503.2 ; v1(171.48,41.68) 170.46,41.68 169.73,40.95 169.73,35.9 v1(170.41,35.22)
LCD_TST_C: length 7.2
  TOP w0.089: v1(220.22,40.23) 221.69,40.23 222,39.93 RN5503.7
  BOTTOM w0.089: v2(216.36,40.93) 218.19,41.55 LCD1.32 219.27,41.55 219.57,41.25 219.76,41.25 220.22,40.79 v1(220.22,40.23)
LCD_VCC_TEST_EN: length 276
  TOP w0.089: v1(171.91,63.32) 171.91,63.96 172.16,64.21 172.16,68.74 172.74,69.32 172.74,70.13 172.34,70.54 172.34,73.2 171.65,73.89 v1(170.13,73.89) ; D5502.2 158.18,77.5 v1(158.12,77.44) v2(158.14,76.88) ; U2401.113 31.16,72.46 30.43,71.74 30.43,71.1 v1(29.94,70.6)
  L5 w0.089: v1(108.08,41.58) 108.08,40.27 108.08,38.28 107.17,37.37 107.17,36.61 106.18,35.62 106.08,35.52 103.11,35.52 101.57,33.98 98.51,33.98 97.76,34.73 94.92,34.73 94.88,34.77 54.46,34.77 52.63,32.94 35.55,32.94 30.77,28.16 29.56,28.16 29.49,28.09 22.2,28.09 17.73,32.57 17.73,35.66 17.73,35.8 17.24,36.29 17.24,49.91 17.56,50.22 17.66,50.32 17.66,56.94 21.43,60.71 22.36,60.71 23.32,61.68 23.32,62.2 27.54,66.43 27.54,67.44 29.92,69.81 29.92,70.58 v1(29.94,70.6)
  L6 w0.089: v1(170.13,73.89) 169.73,73.89 169.04,73.2 165.87,73.2 165.23,73.84 165.23,74.55 164.36,75.42 163.62,75.42 161.85,77.19 158.37,77.19 v1(158.12,77.44) ; v1(171.91,63.32) 171.56,62.98 171.56,61.51 173.16,59.91 173.16,54.4 173.77,53.79 173.77,47.76 173.39,47.39 173.39,46.62 173.92,46.1 174.07,46.1 174.42,45.74 174.42,41.79 172.97,40.34 172.85,40.34 169.24,36.73 165.89,36.73 165.21,36.04 160.64,36.04 159.8,36.89 158.4,36.89 156.5,34.98 149.02,34.98 144.15,39.85 130.6,39.85 130.49,39.96 129.94,40.51 129.09,40.51 128.43,41.17 128.43,41.64 125.73,44.35 111.45,44.35 109.91,42.8 109.3,42.8 v1(108.08,41.58)
LCDVDD_EN: length 128.8
  TOP w0.089: v1(158.12,80.34) 157.97,80.48 D5502.3 ; v1(219.92,36.25) 220.25,35.92 v2(220.5,35.92) 220.7,36.12 220.7,36.53 221.18,37.01 222.02,37.01 222.13,37.11 RN5502.3
  L3 w0.089: v1(177.17,71.71) 177.42,71.96 178.16,71.96 182.52,67.61 182.52,64.46 184.99,61.98 196.76,61.98 198.89,64.11 218.29,64.11 v1(219.13,64.95)
  L6 w0.089: v1(158.12,80.34) 158.24,80.34 158.52,80.62 162.4,80.62 162.69,80.34 163.64,80.34 164.09,79.89 164.09,79.42 169.16,74.35 171.16,74.35 172.78,72.73 172.97,72.73 174.07,71.63 177.02,71.63 177.09,71.71 v1(177.17,71.71) ; v1(219.92,36.25) 219.36,36.25 216.94,38.66 215.83,38.66 212.91,41.58 212.91,42.39 212.65,42.64 212.25,42.64 212.01,42.88 212.01,45.61 212.57,46.17 212.57,46.57 212.27,46.86 212.27,48.7 211.47,49.5 210.7,49.5 210.34,49.86 210.34,51.88 208.97,53.26 208.97,54.08 209.25,54.36 211.89,54.36 v1(212.32,54.79) 212.22,54.89 212.22,55.53 213.17,56.48 213.86,56.48 214.58,55.75 217.4,55.75 219.64,57.99 220.25,57.99 221.11,58.85 221.11,62.76 219.13,64.75 v1(219.13,64.95)
  BOTTOM w0.089: U5501.4 211.62,51.3 212.19,51.87 212.19,53.51 212.32,53.63 v1(212.32,54.79)
LCDVDD_PG: length 224.5
  TOP w0.089: Q5504.1 55.74,62.47 v2(56.67,61.55) 56.98,61.24 99.48,61.24 99.72,60.99 100.54,60.99 100.81,61.27 106.25,61.27 113.97,68.99 113.97,69.78 v1(113.99,69.79) ; v1(155.15,69.52) 155.15,69.01 155.27,68.89 156.92,68.89 157.25,68.55 157.25,68.23 158.22,67.26 158.22,63.05 159.74,61.53 160.86,61.53 164.51,57.88 164.64,57.88 164.66,57.87 165.67,57.87 166.3,57.24 v1(166.3,57.19) ; v1(178.31,67.41) 179.15,67.41 180.15,66.41 180.15,63.55 183.04,60.66 187.93,60.66 191.8,64.53 v1(191.8,65) ; R5548.2 222.43,66.37 223,66.37 v1(223.47,66.85)
  L3 w0.089: v1(223.47,66.85) 223.09,67.23 221.56,67.23 220.5,66.17 210.49,66.17 209.81,65.48 192.28,65.48 v1(191.8,65)
  L5 w0.089: v1(166.3,57.19) 166.03,56.92 164.7,56.92 164.02,56.24 127.66,56.24 118.9,65.01 118.9,66.12 115.75,69.27 114.51,69.27 v1(113.99,69.79)
  BOTTOM w0.089: v1(155.15,69.52) 157.39,67.27 178.17,67.27 v1(178.31,67.41)
LCDVDD_PWRGD: length 12
  TOP w0.089: R5553.1 213.62,67.06 v2(221.03,67.06) 221.26,67.06 C5535.1 222.15,68.07 221.55,68.67 D5505.K 221.42,68.89 R5552.1
LDO1_CAP: length 3.3
  TOP w0.203: HDA27.21 24.43,11.28
  TOP w0.254: 24.43,11.28 23.8,10.64 23.57,10.64 C2703.1 23.14,10.21 23.14,9.91 22.84,9.6 R2702.1
LDO2_CAP: length 4.8
  TOP w0.203: HDA27.32 29.72,12.37 30.58,11.51
  TOP w0.254: 30.58,11.51 v2(30.58,11.46) 30.64,11.46 31.81,10.29 32.92,10.29 C2711.1
LDO3_CAP: length 2.4
  TOP w0.203: C2722.1 25.89,17.74 26.43,17.2 26.44,17.2 v2(26.46,17.17) 26.47,17.16 26.47,17.16 26.73,16.9 HDA27.6
LID_CL_SIO#: length 367.2
  TOP w0.089: RN6401.1 209.93,62.56 v1(210.29,62.92) ; v1(40.65,61.16) 41.76,60.05 41.76,54.08 42.67,53.17 42.67,52.98 43.35,52.3 44.76,52.3 44.86,52.4 U2402.2 ; v1(15.07,22.45) 15.07,23.24 15.67,23.85 15.67,29.09 16.61,30.02 18.42,30.02 21.58,33.18 22.68,33.18 23.04,33.54 23.04,35.26 23.32,35.54 25.35,35.54 26.5,36.68 26.5,39.91 27.49,40.9 27.49,44.56 27.77,44.83 28.3,44.83 29.7,43.44 v2(30.53,43.44) 32.26,43.44 32.68,43.85 33.38,43.85 33.63,44.09 33.63,45.84 33.59,45.88 33.59,49.64 33.84,49.9 35.49,49.9 36.43,48.96 36.43,48.59 37.14,47.88 38.82,47.88 39.38,47.33 39.73,47.33 40.31,47.9 40.31,50.05 41.08,50.83 41.08,53.89 40.11,54.87 40.11,57.51 40.64,58.04 v1(40.64,60.07) 40.22,60.49 U2401.66 ; R2498.2 108.33,31.55 v1(108.87,31.01)
  L3 w0.089: v1(210.29,62.92) 211.19,62.92 212.61,61.49 214.26,61.49 219.1,56.66 219.1,38.76 218.24,37.9 216.95,37.9 216.66,37.9 216.27,37.51 216.27,37.51 215.91,37.15 215.7,36.95 212.74,36.95 212.24,37.45 209.56,37.45 206.06,33.96 200.51,33.96 198,31.45 189.94,31.45 189.21,32.18 176.33,32.18 175.42,32.18 173.22,34.39 168.56,34.39 168.36,34.59 166.55,34.59 166.42,34.72 151,34.72 149.81,33.52 145.46,33.52 144.25,32.31 v1(136.4,32.31)
  L5 w0.089: v1(136.4,32.31) 136.25,32.16 132.81,32.16 130.49,34.48 129.86,34.48 127.14,37.21 127.14,37.64 125.89,38.89 124.43,38.89 122,41.32 112.8,41.32 112.23,40.74 112.23,37.13 111.85,36.75 111.85,34.64 110.87,33.66 110.87,32.21 109.71,31.06 108.91,31.06 v1(108.87,31.01) 106.03,28.18 94.54,28.18 93.18,29.54 91.41,29.54 89.91,28.03 46.35,28.03 45.87,27.55 40.77,27.55 35.14,21.92 35.14,21.7 33.38,19.94 33.38,19.36 33.02,19 30.14,19 29.85,18.7 25.29,18.7 21.54,22.45 20.6,22.45 19.9,23.16 15.77,23.16 v1(15.07,22.45)
  BOTTOM w0.089: v1(136.4,32.31) 136.57,32.48 136.57,35.28 136.19,35.66 134.29,35.66 130.81,39.15 D2402.K ; v1(210.29,62.92) 211.64,64.27 219.39,64.27 220.02,64.9 220.65,64.9 221.01,64.54 221.01,63.81 221.34,63.48 222.2,63.48 222.45,63.22 FP1.6 ; v1(40.64,60.07) 40.65,60.08 v1(40.65,61.16)
LID_CLOSE#_C: length 11.3
  TOP w0.089: v1(211.66,54.92) 211.71,54.92 212.17,55.37 EC6401.1 212.14,55.55 211.71,55.98 210.92,55.98 AFTP6401.1 209.96,56.74 209.38,56.74 209.12,57.01 209.12,57.81 209.93,58.62 RN6401.4
  BOTTOM w0.089: PWR1.3 212.45,55.57 ED6401.2 211.8,54.92 v1(211.66,54.92)
LINE1-L_C: length 11.7
  TOP w0.254: R2922.1 24.82,8.64 v1(24.77,8.64) ; C2907.2 19.18,12.63 v1(19.05,12.5) 18.95,12.5 v2(18.51,12.93)
  L3 w0.254: v1(19.05,12.5) 20.62,12.5 22.65,10.47 24.38,10.47 25.4,9.44 25.4,8.84 25.2,8.64 v1(24.77,8.64)
LINE1-L_R: length 12.9
  TOP w0.254: v1(19.05,13.13) 18.89,13.3 v2(18.89,14.23) 19.51,14.23 C2908.2 ; R2921.1 v1(27.13,8.74)
  L3 w0.254: v1(19.05,13.13) 20.7,13.13 22.86,10.97 24.64,10.97 26.88,8.74 v1(27.13,8.74)
LINE1_L: length 3.3
  TOP w0.203: HDA27.18 23.35,12.77
  TOP w0.254: C2907.1 21.38,12.77 23.35,12.77
LINE1_R: length 3.5
  TOP w0.203: HDA27.17 23.72,13.17 23.7,13.19 v2(23.54,13.19)
  TOP w0.254: C2908.1 21.57,13.82 22.1,13.29 22.51,13.29 22.59,13.2 23.53,13.2 v2(23.54,13.19)
LINE1_VREFO: length 5.5
  TOP w0.203: 26.33,10.31 26.38,10.37 26.38,10.81 26.33,10.86 HDA27.24
  TOP w0.254: D2901.3 24.23,8.25 24.23,9.63 v2(24.39,9.78) 24.72,10.11 25.7,10.11 25.71,10.1 26.11,10.1 26.33,10.31
LINE1_VREFO_D1: length 6.8
  TOP w0.254: D2901.1 24.37,4.93 24.38,4.92 27.93,4.92 v2(28.07,5.06) R2912.1
LINE1_VREFO_D2: length 3.7
  TOP w0.254: R2913.1 26.39,7.29 25.72,6.62 D2901.2 26.59,5.6 v2(26.77,5.43)
LOM_CABLE_DETECT#: length 84.7
  TOP w0.089: v1(49.59,87.58) 49.78,87.58 50.65,86.71 R3104.2
  L5 w0.089: v1(52.1,89.61) 54.7,92.22 54.7,93.48 56.12,94.9 57.61,94.9 60.02,97.31 62.24,97.31 62.5,97.05 65.81,97.05 67.34,98.58 73.36,98.58 73.67,98.88 86.26,98.88 86.79,99.41 96.51,99.41 97.54,98.38 97.54,95.52 100.66,92.4 100.66,91.53 101.17,91.02 101.87,91.02 102.21,91.37 103.18,91.37 104.32,90.23 104.91,90.23 104.92,90.23 106.59,90.23 106.64,90.19 107.96,90.19 110.36,87.79 110.36,85.51 109.99,85.14 109.99,83.17 109.99,83.16 109.99,83.05 v1(110.44,82.6)
  BOTTOM w0.076: CPU1.CK34 110.42,84.67 110.42,84.44 110.43,84.44 110.83,84.04 110.89,83.95 110.9,83.88
  BOTTOM w0.089: 110.9,83.88 110.9,83.06 v1(110.44,82.6) ; v1(52.1,89.61) v2(51.55,89.07) 50.07,87.58 v1(49.59,87.58)
LOM_TCT: length 10.4
  TOP w0.089: XF3201.10 37.53,84.09 v1(38,83.62) 37.53,83.15 XF3201.9
  BOTTOM w0.089: v1(38,83.62) 37.53,83.15 XF3202.10 ; v1(38,83.62) 37.53,84.09 XF3202.9 ; v1(38,83.62) 38.18,83.8 C3203.1 38.97,83.65 v2(38.97,83.01)
LPS_SW: length 24.4
  TOP w0.127: v2(29.38,112.47) 29.38,111.94 29.12,111.68 28.76,111.68 28.63,111.81 R7401.2 27.44,111.81 v1(27.36,111.74) ; v1(32.41,122.94) 32.49,122.94 33.37,123.82 C7401.2 33.63,123.88 R7407.1 34.33,123.18 R7403.1 34.47,123.19 U7418.4
  L5 w0.127: v1(33.05,112.54) 33.49,112.98 33.49,118.58 33.19,118.89 33.19,120.92 33.21,120.94 33.21,122.14 v1(32.41,122.94)
  BOTTOM w0.127: v1(33.05,112.54) 32.73,112.85 31.01,112.85 29.82,111.66 28.73,111.66 28.37,112.02 27.56,112.02 27.36,111.81 v1(27.36,111.74)
LPS_SW_A: length 3
  TOP w0.127: v2(29.31,111.18) 28.81,111.18 28.58,110.95 R7401.1 28.12,110.67 29,109.79 Q7406.3
LPS_SW_C: length 21.5
  TOP w0.127: R7408.1 31.42,107.03 v2(32.48,107.03) 32.48,107.47 v1(32.2,107.75) 32.07,107.88 R7406.2 ; Q7401.G 32.35,123.99 v1(31.35,122.99)
  L5 w0.127: v1(32.2,107.75) 32.56,108.12 32.56,108.91 31.92,109.56 31.92,111.32 32.57,111.97 32.57,120.7 32.96,121.1 32.96,121.67 32.2,122.43 31.91,122.43 v1(31.35,122.99)
LPS_SW_D: length 2
  TOP w0.127: Q7406.6 30.47,107.14 R7408.2 29.72,107.13 v2(29.56,106.97)
LPS_SW_R: length 2.5
  TOP w0.114: Q7401.D 32.59,122.17 33.53,123.12
M2_PCIE_LED#: length 10.3
  TOP w0.089: D6401.2 32.7,21.45 v1(32.21,21.94) 31.66,21.39 31.23,21.39 31.1,21.52 31.1,22.04 31.49,22.43 v2(31.49,22.45) 31.49,22.52 31.35,22.66 R6411.2
  BOTTOM w0.089: v1(32.21,21.94) 32.21,21.87 32.9,21.18 33.3,21.18 34.2,22.08 SSD1.10
M2_SSD_PEDET: length 186.5
  TOP w0.089: R6348.2 28.78,25.43 v1(29.95,26.6) 30.17,26.6 37.18,33.61 51.26,33.61 51.73,34.08 51.73,41.37 51.49,41.61 v2(51.49,43.23) 51.49,43.41 51.72,43.64 51.72,50.88 56.62,55.78 98.1,55.78 98.35,55.53 110.03,55.53 124.79,70.29 124.79,89.72 122.91,91.6 122.91,93.75 119.81,96.85 119.81,99.26 118.19,100.88 v1(117.6,100.88)
  L5 w0.089: v1(29.95,26.6) 29.7,26.34 29.7,26.24 29.44,25.99 29.21,25.99 29.21,25.99 26.79,25.99 26.5,25.7 22.81,25.7 19.38,29.14 18.88,29.14 16.29,31.73 v1(16.29,33.56)
  BOTTOM w0.076: 115.03,100.61 113.44,100.61 113.38,100.63 113.14,100.63 CPU1.CP10
  BOTTOM w0.089: v1(117.6,100.88) 117.2,100.48 115.21,100.48 115.08,100.61 115.03,100.61 ; SSD1.69 19.45,33.21 19.31,33.35 16.49,33.35 16.29,33.55 v1(16.29,33.56)
M_A_A0: length 57.1
  L5 w0.14: v1(80.14,77.22) 79.43,76.5 79.43,75.07 78.79,74.43 78.79,66.57 69.58,57.36 69.58,57.16 70.17,56.57 70.17,56.37 69.97,56.17 69.78,56.17 69.18,56.77 68.99,56.77 68.79,56.57 68.79,56.37 69.38,55.78 69.38,55.58 69.18,55.38 68.99,55.38 68.39,55.98 68.2,55.98 68,55.78 68,55.58 68.59,54.99 68.59,54.79 68.39,54.59 68.2,54.59 67.6,55.19 67.4,55.19 67.21,54.99 67.21,54.79 67.8,54.2 67.8,54 63.47,49.67 63.47,47.28 v1(64.16,46.58)
  BOTTOM w0.076: CPU1.AC37 81.66,83.7 81.66,82.96 81.87,82.75 81.87,80.67 81.77,80.57
  BOTTOM w0.14: 81.77,80.57 81.23,80.04 81.23,78.31 v1(80.14,77.22) ; DM1.144 66.12,42.94 66.12,46.23 65.67,46.68 64.26,46.68 v1(64.16,46.58)
M_A_A1: length 58.2
  L5 w0.14: v1(64.37,48.52) 64.91,49.06 64.91,50.52 71.04,56.65 71.04,56.84 70.61,57.27 70.61,57.45 70.83,57.67 71.01,57.67 71.44,57.24 71.63,57.24 71.83,57.44 71.83,57.63 71.25,58.21 71.25,58.41 71.45,58.61 71.65,58.61 72.23,58.03 72.42,58.03 72.62,58.23 72.62,58.42 72.04,59 72.04,59.2 72.24,59.4 72.44,59.4 73.02,58.82 73.21,58.82 73.41,59.02 73.41,59.21 72.83,59.79 72.83,59.99 73.03,60.19 73.23,60.19 73.81,59.61 74,59.61 74.2,59.81 74.2,60 73.62,60.59 73.62,60.78 73.82,60.98 74.02,60.98 74.6,60.4 74.79,60.4 74.99,60.6 74.99,60.8 74.41,61.38 74.41,61.57 74.61,61.77 74.81,61.77 75.39,61.19 75.59,61.19 75.78,61.39 75.78,61.59 75.2,62.17 75.2,62.36 79.25,66.41 79.25,74.49 79.71,74.95 79.71,75.13 79.7,75.14 79.7,75.5 79.71,75.51 79.71,75.52 v1(80.14,75.95)
  BOTTOM w0.076: CPU1.AC36 81.82,84.45 81.98,84.17 81.98,84.17 82.08,83.98 82.08,83.71 81.86,83.48 81.86,83 82.03,82.82 82.03,80.35 81.78,80.1
  BOTTOM w0.14: 81.78,80.1 81.59,79.91 81.59,79.8 81.57,79.78 81.57,78.01 80.85,77.29 80.85,76.66 v1(80.14,75.95) ; DM1.133 63.33,48.9 63.71,48.52 v1(64.37,48.52)
M_A_A2: length 56.9
  L5 w0.14: v1(80.14,77.88) 79.15,76.89 79.15,75.18 78.34,74.37 78.34,66.75 66.44,54.86 66.44,54.66 67.06,54.05 67.06,53.85 66.86,53.65 66.66,53.65 66.05,54.27 65.85,54.27 65.65,54.07 65.65,53.87 66.27,53.26 66.27,53.06 66.07,52.86 65.87,52.86 65.26,53.48 65.06,53.48 64.86,53.28 64.86,53.08 65.48,52.47 65.48,52.27 65.28,52.07 65.08,52.07 64.84,52.31 64.66,52.31 64.44,52.1 64.44,51.92 64.69,51.68 64.69,51.48 63.05,49.84 63.05,46.88 63.98,45.96 v1(63.98,45.79)
  BOTTOM w0.076: CPU1.AC34 81.57,85.55 81.57,84.39 81.59,84.33 81.59,84.03 81.5,83.78 81.5,82.64 81.7,82.44 81.7,80.94 81.47,80.71
  BOTTOM w0.14: v1(80.14,77.88) 80.97,78.71 80.97,80.2 81.47,80.71 ; DM1.132 63.08,44.89 v1(63.98,45.79)
M_A_A3: length 57.7
  L5 w0.14: v1(80.13,75.31) 80.13,74.97 79.76,74.61 79.76,64.77 79.46,64.47 79.27,64.47 78.68,65.06 78.49,65.06 78.29,64.86 78.29,64.66 78.87,64.08 78.87,63.88 78.67,63.68 78.47,63.68 77.89,64.27 77.7,64.27 77.5,64.07 77.5,63.87 78.08,63.29 78.08,63.09 77.88,62.89 77.68,62.89 77.1,63.47 76.91,63.47 76.71,63.28 76.71,63.08 77.29,62.5 77.29,62.3 77.09,62.1 76.89,62.1 76.31,62.68 76.12,62.68 75.92,62.49 75.92,62.29 76.5,61.71 76.5,61.51 65.33,50.35 65.33,48.46 65.33,48.16 v1(64.39,47.22)
  BOTTOM w0.076: CPU1.AC35 82.14,84.84 82.14,84.21 82.24,84.02 82.24,83.64 82.02,83.42 82.02,83.07 82.2,82.89 82.2,80.06 82.07,79.94
  BOTTOM w0.14: DM1.131 62.83,48.78 64.39,47.22 v1(64.39,47.22) ; v1(80.13,75.31) 80.13,75.32 81.32,76.51 81.32,77.09 81.82,77.59 81.82,79.68 82.07,79.94
M_A_A4: length 55.6
  L5 w0.14: v1(80.09,79.79) 78.59,78.29 78.59,75.63 77.47,74.52 77.47,68.02 73.42,63.97 73.42,63.77 73.7,63.5 73.7,63.3 73.5,63.1 73.3,63.1 73.03,63.38 72.83,63.38 72.63,63.18 72.63,62.98 72.91,62.71 72.91,62.51 72.71,62.31 72.51,62.31 72.24,62.59 72.04,62.59 71.84,62.39 71.84,62.19 72.12,61.92 72.12,61.72 71.92,61.52 71.72,61.52 71.45,61.8 71.25,61.8 71.05,61.6 71.05,61.4 71.33,61.13 71.33,60.93 71.13,60.73 70.93,60.73 70.66,61.01 70.46,61.01 70.26,60.81 70.26,60.61 70.54,60.34 70.54,60.14 62.18,51.79 62.18,48.59 61.6,48 61.6,45.71 61.99,45.32 v1(62.59,45.32)
  BOTTOM w0.076: CPU1.AA35 80.62,85.06 80.79,84.6 80.79,84.41 80.74,84.3 80.74,84.06 80.8,83.9 80.8,83.61 80.81,83.6 80.81,82.87 80.8,82.87 80.8,82.83 80.37,82.4 80.37,82.08
  BOTTOM w0.14: 80.37,82.08 80.37,80.07 v1(80.09,79.79) ; v1(62.59,45.32) 62.08,44.81 DM1.128
M_A_A5: length 57.3
  L5 w0.14: v1(62.31,46.64) 62.54,46.64 62.77,46.41 62.78,46.41 63.04,46.14 63.04,46.14 63.06,46.12 63.06,44.88 64.05,43.88 65.75,43.88 66.39,44.53 66.39,49.86 80.81,64.28 80.81,73.88 80.98,74.04 80.98,80.59 81.21,80.82 v1(81.21,81.08)
  BOTTOM w0.076: CPU1.AB35 81.17,84.82 81.28,84.71 81.43,84.3 81.43,84.06 81.36,83.87 81.33,83.85 81.33,82.58 81.54,82.37 81.54,81.41 v1(81.21,81.08)
  BOTTOM w0.14: v1(62.31,46.64) 61.83,46.64 61.58,46.38 DM1.126
M_A_A6: length 55.6
  L5 w0.14: v1(78.11,75.82) 78.11,75.55 77.04,74.48 77.04,68.28 69.48,60.72 69.48,60.52 69.81,60.2 69.81,60 69.61,59.8 69.41,59.8 69.09,60.13 68.89,60.13 68.69,59.93 68.69,59.73 69.01,59.41 69.01,59.21 68.82,59.01 68.62,59.01 68.3,59.34 68.1,59.34 67.9,59.14 67.9,58.94 68.22,58.62 68.22,58.42 68.03,58.22 67.83,58.22 67.5,58.55 67.31,58.55 67.11,58.35 67.11,58.15 67.43,57.83 67.43,57.63 67.24,57.43 67.04,57.43 66.71,57.75 66.52,57.75 66.32,57.56 66.32,57.36 66.64,57.04 66.64,56.84 66.45,56.64 66.25,56.64 65.92,56.96 65.73,56.96 65.53,56.77 65.53,56.57 65.85,56.24 65.85,56.05 65.66,55.85 65.46,55.85 65.13,56.17 64.94,56.17 64.74,55.98 64.74,55.78 65.06,55.45 65.06,55.26 64.86,55.06 64.67,55.06 64.34,55.38 64.15,55.38 63.95,55.19 63.95,54.99 64.27,54.66 64.27,54.47 64.07,54.27 63.88,54.27 63.55,54.59 63.35,54.59 63.16,54.4 63.16,54.2 63.48,53.87 63.48,53.68 63.28,53.48 63.09,53.48 62.76,53.8 62.56,53.8 62.37,53.6 62.37,53.41 62.69,53.08 62.69,52.89 62.49,52.69 62.3,52.69 61.97,53.01 61.77,53.01 61.48,52.72 61.48,49.68 v1(61.65,49.51)
  BOTTOM w0.076: 80.06,82.09 80.06,82.37 80.64,82.94 80.64,83.74 CPU1.AA37
  BOTTOM w0.14: v1(61.65,49.51) 61.83,49.68 DM1.127 ; v1(78.11,75.82) 78.18,75.82 79.59,77.23 79.59,79.87 79.66,79.94 79.66,79.97 79.91,80.22 79.94,80.22 80.06,80.34 80.06,82.09
M_A_A7: length 55.9
  L5 w0.14: v1(78.08,76.46) 77.66,76.46 77.54,76.33 77.54,75.53 76.61,74.6 76.61,73.19 76.47,73.05 76.2,73.05 76.06,72.91 76.06,72.63 76.2,72.49 76.47,72.49 76.61,72.35 76.61,72.07 76.47,71.93 76.2,71.93 76.06,71.79 76.06,71.51 76.2,71.37 76.47,71.37 76.61,71.23 76.61,70.82 76.47,70.68 76.19,70.68 76.06,70.55 76.06,70.28 76.23,70.12 76.47,70.12 76.61,69.98 76.61,69.7 76.47,69.56 76.19,69.56 76.06,69.43 76.06,69.16 76.23,69 76.47,69 76.61,68.86 76.61,68.44 61.06,52.89 61.06,49.51 61.17,49.4 61.17,44.98 61.29,44.85 61.93,44.85 62.06,44.72 62.06,44.04 61.93,43.92 60.99,43.92 v1(60.58,44.34)
  BOTTOM w0.076: 79.8,82.07 79.8,82.33 80.47,83.01 80.47,83.49 80.27,83.69 80.27,83.99 80.3,84.05 80.36,84.11 80.52,84.44 CPU1.AA36
  BOTTOM w0.14: DM1.122 v1(60.58,44.34) ; 79.8,82.07 79.82,82.05 79.82,80.53 79.25,79.96 79.25,77.63 v1(78.08,76.46)
M_A_A8: length 54.9
  L5 w0.14: v1(80.12,79.16) 78.87,77.91 78.87,75.38 77.9,74.42 77.9,66.93 77.35,66.38 77.16,66.38 76.89,66.65 76.69,66.65 76.49,66.45 76.49,66.25 76.76,65.98 76.76,65.79 76.56,65.59 76.37,65.59 76.1,65.86 75.9,65.86 75.7,65.66 75.7,65.46 75.97,65.19 75.97,65 75.77,64.8 75.58,64.8 75.31,65.07 75.11,65.07 74.91,64.87 74.91,64.67 75.18,64.4 75.18,64.21 74.98,64.01 74.79,64.01 74.52,64.28 74.32,64.28 74.12,64.08 74.12,63.88 74.39,63.61 74.39,63.4 63.52,52.53 63.52,52.35 64.02,51.86 64.02,51.68 63.82,51.48 63.6,51.48 63.14,51.94 62.96,51.94 62.63,51.61 62.63,48.23 v1(62.36,47.96)
  BOTTOM w0.076: CPU1.AB34 80.92,85.23 80.92,84.72 80.95,84.63 80.95,84.38 80.92,84.29 80.92,84.07 80.97,83.93 80.97,83.93 80.97,82.7 80.7,82.42 80.7,81.97
  BOTTOM w0.14: 80.7,81.97 80.7,79.73 v1(80.12,79.16) ; DM1.125 61.33,50.06 61.2,49.94 61.2,48.5 61.75,47.96 v1(62.36,47.96)
M_A_A9: length 54.1
  L5 w0.14: v1(59.65,47.48) 59.14,46.97 58.89,46.97 58.77,47.1 58.77,50.79 58.91,50.93 59.66,50.93 59.8,51.07 59.8,51.35 59.66,51.49 58.91,51.49 58.77,51.63 58.77,51.93 58.93,52.1 59.62,52.1 59.74,52.22 59.74,53.35 73.13,66.74 73.13,72.48 75.78,75.12 75.89,75.12 76.7,75.93 76.7,78.53 77.83,79.66 v1(78.05,79.66)
  BOTTOM w0.076: CPU1.W36 79.29,84.47 79.56,83.98 79.56,83.71 79.34,83.48 79.34,82.7 79.1,82.46 79.1,81.79 78.85,81.55 78.85,81.43
  BOTTOM w0.14: DM1.121 60.33,50.09 60.42,49.99 60.42,47.62 60.12,47.32 59.8,47.32 v1(59.65,47.48) ; 78.85,81.43 78.85,80.86 78.81,80.81 78.81,80.8 78.5,80.49 78.5,80.1 v1(78.05,79.66)
M_A_A10: length 55
  L5 w0.14: v1(78.94,87.2) 79.49,86.66 79.49,85.35 82.58,82.25 82.58,79.74 82.73,79.59 82.73,78.25 82.77,78.22 82.77,77.79 82.95,77.6 82.95,63.29 82.92,63.26 82.92,63.11 69.44,49.62 69.44,49.32 69.56,49.19 69.79,49.19 69.95,49.03 69.95,48.62 69.77,48.44 68.98,48.44 68.86,48.31 68.86,47.09 68.84,47.08 68.84,46.04 v1(69.27,45.62)
  BOTTOM w0.14: v1(69.27,45.62) 68.9,45.62 68.57,45.3 68.57,44.84 68.58,44.84 DM1.146 ; v1(78.94,87.2) 78.96,87.19 79.99,87.19 CPU1.Y31
M_A_A11: length 53.2
  L5 w0.14: v1(60.58,45.65) 60.38,45.44 59.77,45.44 59.64,45.57 59.64,46.03 60.16,46.55 60.16,47.78 59.5,48.44 59.5,49.82 60.22,50.54 60.22,53.24 73.57,66.58 73.57,72.32 76.98,75.73 76.98,77.31 v1(78.05,78.39)
  BOTTOM w0.076: 79.26,81.57 79.26,82.39 79.5,82.63 79.5,83.39 79.72,83.61 79.72,84.02 79.61,84.23 79.61,85.18 CPU1.W34
  BOTTOM w0.14: DM1.120 60.07,42.91 60.07,45.13 v1(60.58,45.65) ; v1(78.05,78.39) 78.49,78.82 78.49,79.77 78.73,80.01 78.73,80.28 78.82,80.37 78.82,80.49 79.04,80.71 79.04,80.71 79.26,80.94 79.26,81.57
M_A_A12: length 54.8
  L5 w0.14: v1(59.97,49.46) 60.24,49.19 60.51,49.19 60.64,49.31 60.64,52.72 60.64,52.72 60.64,53.06 74.25,66.67 74.25,68.02 74.37,68.15 75.7,68.15 75.87,68.32 75.87,68.58 75.7,68.75 74.34,68.75 74.2,68.89 74.2,69.17 74.34,69.31 75.5,69.31 75.64,69.45 75.64,69.73 75.5,69.87 74.34,69.87 74.2,70.01 74.2,70.28 74.34,70.42 75.5,70.42 75.64,70.56 75.64,72.41 75.5,72.55 75.2,72.55 75.06,72.69 75.06,72.97 75.2,73.11 75.5,73.11 75.64,73.25 75.64,74.02 77.26,75.64 77.26,77.15 77.83,77.73 v1(78.05,77.73)
  BOTTOM w0.076: CPU1.AA34 80.52,85.8 80.21,85.15 80.21,84.21 80.18,84.17 80.17,84.15 80.1,84.04 80.1,83.62 80.3,83.42 80.3,83.07 79.53,82.3 79.53,81.84
  BOTTOM w0.14: DM1.119 59.83,49.6 v1(59.97,49.46) ; v1(78.05,77.73) 78.59,77.73 78.96,78.09 78.96,80.05 79.53,80.62 79.53,81.84
M_A_A13: length 56.9
  L5 w0.14: v1(81.69,86.59) 81.69,85.67 82.73,84.62 82.99,84.62 83.93,83.68 85.12,83.68 85.37,83.43 85.37,77.02 85.17,76.82 85.17,61.39 78.07,54.29 78.07,54.09 78.34,53.83 78.34,53.65 78.12,53.43 77.94,53.43 77.68,53.7 77.48,53.7 77.28,53.5 77.28,53.3 77.74,52.84 77.74,52.65 77.54,52.45 77.35,52.45 76.89,52.91 76.69,52.91 76.49,52.71 76.49,52.51 76.95,52.05 76.95,51.86 76.75,51.66 76.56,51.66 76.1,52.12 75.9,52.12 75.27,51.49 74.32,51.49 72.57,49.73 72.57,47.14 72.03,46.6 72.03,45.07 v1(72.09,45.01)
  BOTTOM w0.14: DM1.158 71.58,44.49 v1(72.09,45.01) ; CPU1.AC32 v1(81.69,86.59)
M_A_A14: length 57.2
  L5 w0.14: v1(81.67,87.27) 81.29,86.89 81.29,86.79 81.21,86.71 81.21,86.41 81.08,86.28 81.08,85.69 82.38,84.38 82.89,84.38 83.56,83.71 83.56,83.41 84.38,82.59 84.38,79.13 85.07,78.45 85.07,77.26 84.76,76.95 84.76,61.56 81.51,58.32 81.32,58.32 81.04,58.6 80.84,58.6 80.64,58.4 80.64,58.2 80.92,57.93 80.92,57.73 80.72,57.53 80.52,57.53 80.25,57.81 80.05,57.81 79.85,57.61 79.85,57.41 80.13,57.14 80.13,56.94 79.93,56.74 79.73,56.74 79.46,57.02 79.26,57.02 79.06,56.82 79.06,56.62 79.34,56.34 79.34,56.15 79.14,55.95 78.94,55.95 78.67,56.23 78.47,56.23 78.27,56.03 78.27,55.83 78.55,55.55 78.55,55.36 75.1,51.91 74.15,51.91 72.15,49.91 72.15,47.62 v1(71.96,47.43)
  BOTTOM w0.14: DM1.151 69.83,49.53 71.77,47.59 71.8,47.59 v1(71.96,47.43) ; v1(81.67,87.27) 81.93,87.53 CPU1.AC31
M_A_A15: length 55.8
  L5 w0.14: v1(71.48,46.23) 71.51,46.26 71.51,47.61 71.73,47.83 71.73,50.08 74.43,52.78 74.63,52.78 74.88,52.52 75.08,52.52 75.28,52.72 75.28,52.92 75.02,53.17 75.02,53.37 75.22,53.57 75.42,53.57 75.67,53.31 75.87,53.31 76.07,53.51 76.07,53.71 75.81,53.96 75.81,54.16 76.01,54.36 76.21,54.36 76.46,54.1 76.66,54.1 76.86,54.3 76.86,54.5 76.6,54.76 76.6,54.95 76.8,55.15 77,55.15 77.25,54.89 77.45,54.89 77.65,55.09 77.65,55.29 77.39,55.55 77.39,55.74 84.31,62.66 84.31,77.16 84.76,77.6 84.76,78.28 84.14,78.9 84.14,82.49 83.75,82.88 83.54,82.88 83.32,83.1 83.32,83.61 82.79,84.14 82.28,84.14 80.82,85.6 80.82,85.9 80.78,85.95 v1(80.78,86.59)
  BOTTOM w0.14: DM1.156 71.08,45.83 v1(71.48,46.23) ; CPU1.AB32 80.84,86.59 v1(80.78,86.59)
