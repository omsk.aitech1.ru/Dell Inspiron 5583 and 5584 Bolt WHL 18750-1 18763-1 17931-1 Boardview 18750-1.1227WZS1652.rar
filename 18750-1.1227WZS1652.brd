# Allegro board 18750-1.1227WZS1652.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MDO1+: length 18.9
  BOTTOM w0.089: 26.24,81.13 AFTP3202.1 ; 26.24,81.13 26.42,80.95 27.9,80.95 27.99,81.04 27.99,81.32 28.12,81.45 XF3202.2 ; 26.24,81.13 25.71,81.66 22.56,81.66 18.52,77.62 14.76,77.62 14.19,78.18 RJ1.3
MDO1-: length 19
  BOTTOM w0.089: 24.46,81.4 25.6,81.4 26.31,80.68 27.86,80.68 27.99,80.56 27.99,80.31 28.12,80.18 XF3202.1 ; 24.46,81.4 22.67,81.4 18.63,77.35 15.32,77.35 13.95,75.98 RJ1.6 ; 24.46,81.4 AFTP3208.1
MDO2+: length 27.1
  TOP w0.089: 26.37,84.1 24.49,82.22 21.14,82.22 15.17,76.25 13.93,76.25 13.64,76.56 13.64,76.86 RJ1.4 ; 26.37,84.1 AFTP3205.1 ; 26.37,84.1 27.01,84.74 30.33,84.74 30.83,85.23 30.83,88.03 30.55,88.3 30.28,88.3 30.19,88.21 30.19,87.89 30.1,87.8 XF3201.2
MDO2-: length 28.1
  TOP w0.089: RJ1.5 13.15,76.42 13.42,76.4 13.81,75.99 15.28,75.99 19.46,80.17 ; AFTP3207.1 19.46,80.17 ; 19.46,80.17 21.25,81.95 24.6,81.95 27.12,84.47 30.44,84.47 31.09,85.12 31.09,88.14 30.66,88.57 30.28,88.57 30.19,88.66 30.19,88.98 30.1,89.07 XF3201.1
MDO3+: length 27.4
  TOP w0.089: XF3201.6 30.1,80.18 30.19,80.27 30.19,80.59 30.28,80.68 30.62,80.68 30.95,81.01 30.95,83.4 30.42,83.94 27.5,83.94 24.98,81.41 22.25,81.41 19,78.16 ; 19,78.16 15.13,74.29 13.92,74.29 13.78,74.13 13.72,74.13 RJ1.7 ; 19,78.16 AFTP3209.1
MDO3-: length 26.3
  TOP w0.089: 25.75,81.8 27.61,83.67 30.31,83.67 30.69,83.29 30.69,81.12 30.51,80.95 30.28,80.95 30.19,81.04 30.19,81.36 30.1,81.45 XF3201.5 ; 25.75,81.8 AFTP3206.1 ; 25.75,81.8 25.09,81.14 22.36,81.14 15.24,74.02 14.04,74.02 13.95,73.92 13.92,73.89 RJ1.8
ME_FWP: length 85.6
  TOP w0.089: v1(29.85,33.94) 29.75,33.83 29.75,31.55 v1(29.21,31.01) ; v1(37.87,66.14) 37.92,66.09 U2401.80 ; v1(12.96,40.78) 13.02,40.84 14.2,40.84 15.7,39.35 16.36,39.35 17.12,40.11 AFTP6803.1
  L3 w0.089: v1(14,25.68) 14.65,26.33 14.65,38.79 12.96,40.48 v1(12.96,40.78) ; v1(37.87,66.14) 38.51,65.5 38.51,61.8 37.48,60.76 37.42,60.76 31.42,54.76 31.42,53.23 26.9,48.72 26.9,42.34 28.86,40.39 28.86,39.39 28.55,39.08 28.55,35.4 29.85,34.1 v1(29.85,33.94)
  BOTTOM w0.089: MESW1.3 12.67,41.07 v1(12.96,40.78) ; v1(29.21,31.01) 28.8,30.6 26.09,30.6 25.4,31.29 24.07,31.29 23.9,31.12 20.86,31.12 19.03,29.29 16.18,29.29 15.27,28.37 15.27,26.94 v1(14,25.68)
ME_FWP_R: length 172.5
  TOP w0.089: v1(25.99,22.39) 26.4,22.8 26.4,23.63 26.46,23.68 26.46,28.49 28.1,30.13 28.1,32.57 28.71,33.17 28.71,35.05 31.63,37.97 31.63,40.26 31.88,40.51 34.56,40.51 35.36,41.31 35.36,42.11 36.43,43.19 41.08,43.19 41.74,43.85 44.69,43.85 45.16,44.32 45.16,46.13 45.47,46.43 45.47,49.43 54.71,58.68 99.4,58.68 99.64,58.43 106.87,58.43 116.01,67.57 116.44,67.57 v1(116.46,67.59) ; v1(15.93,39.78) R6878.2 17.12,40.97 AFTP6802.1 16.18,42.8 12.42,42.8 v1(11.86,43.36)
  L3 w0.089: v1(15.93,39.78) 16.96,38.74 16.96,29.69 23.18,23.47 24.06,23.47 25.15,22.39 v1(25.99,22.39)
  BOTTOM w0.089: MESW1.2 11.4,42.9 v1(11.86,43.36) ; v1(116.46,67.59) 116.11,67.59 115.67,67.16 113.13,67.16 105.24,75.05 103.1,77.19 103.1,79.63 R1909.1
ME_SUS_PWR_ACK_R: length 47
  TOP w0.089: R1738.2 136.97,69.51 v1(136.42,69.51) 136.42,69.85 v2(136.24,70.04) 135.32,70.04 R1708.1
  BOTTOM w0.089: CPU1.BV34 104.56,85.48 104.78,85.26 104.78,84 104.89,83.89 104.89,81.49 106.03,80.35 106.03,79.17 106.3,78.89 106.3,76.91 111.92,71.3 114.85,71.3 114.85,71.3 116.06,71.3 118.67,68.68 132.29,68.68 132.54,68.44 135.42,68.44 136.42,69.44 v1(136.42,69.51)
MEC_XTAL1_R: length 4.7
  TOP w0.114: X2401.1 26.61,77 27.33,76.28 C2425.2 27.33,74.75 27.15,74.57 U2401.123
MEC_XTAL2: length 7.2
  TOP w0.114: R2461.2 X2401.2 25.49,76.95 25.85,76.95 C2424.2 26.84,75.96 26.84,74.83 26.74,74.73 26.55,74.73 26.35,74.54 U2401.125
MEM_SMBCLK: length 18.5
  L5 w0.114: v1(115.33,97.41) 115.06,97.14 111.43,97.14 111.06,97.51 111.02,97.51 v1(110.57,97.96)
  BOTTOM w0.114: v1(115.33,97.41) 115.33,97.81 115.49,97.97 116.63,97.97 117.15,97.45 117.15,96.79 117.18,96.75 117.18,96.43 117.65,95.96 117.77,95.96 117.78,95.96 v2(119.61,95.96) 120.34,95.96 121.52,97.14 RN1807.8 121.82,97.49 122.07,97.74 124.39,97.74 124.95,97.18 Q1801.3 ; CPU1.CK14 v1(110.57,97.96)
MEM_SMBDATA: length 20.9
  L5 w0.114: v1(109.99,96.9) 110.37,97.29 110.98,97.29 111.34,96.93 115.45,96.93 115.98,97.46 v1(115.98,97.55)
  BOTTOM w0.114: CPU1.CH15 109.66,97.23 v1(109.99,96.9) ; v1(115.98,97.55) 115.98,97.41 115.67,97.1 115.67,96.68 117.36,95 120.8,95 121.27,95.46 RN1807.5 122.57,94.72 123.27,94.72 v2(123.79,95.24) 123.97,95.42 126.14,95.42 Q1801.6
MESW1_B: length 106.2
  TOP w0.089: R6804.1 R6877.1 85.14,34.29 85.7,33.74 v1(85.7,31.65) ; v1(11.81,43.99) 12.02,43.78 12.03,43.78 12.28,43.54 12.28,43.52 12.83,42.98 16.34,42.98 AFTP6801.1
  L5 w0.089: v1(11.81,43.99) 11.43,43.61 11.43,40.79 14.28,37.94 14.28,35.36 14.53,35.1 14.53,27.95 16.37,26.11 19.73,26.11 21.65,24.2 30.58,24.2 32.36,25.98 32.36,26.83 36.42,30.89 84.98,30.89 85.7,31.6 v1(85.7,31.65)
  BOTTOM w0.089: v1(11.81,43.99) 11.4,44.41 MESW1.1
MIC2_VREFO: length 14.1
  TOP w0.203: HDA27.23 25.93,10.63 v1(25.9,10.61)
  TOP w0.254: RN2901.2 20.55,16.1 v2(19.82,16.1) 19.89,16.18 19.89,16.74 v1(20.04,16.89) 20.15,17 RN2901.1
  L3 w0.254: v1(25.9,10.61) 24.69,11.81 24.69,15.62 23.42,16.89 v1(20.04,16.89)
MIC_CAP: length 8.1
  TOP w0.203: 22.92,13.97 HDA27.15
  TOP w0.254: 22.92,13.97 22.03,14.86 21.98,14.86 21.97,14.87 v2(21.97,14.87) 21.89,14.87 21.14,15.62 19.08,15.62 17.99,14.53 C2715.1
MODEL_ID: length 10.6
  TOP w0.089: R2442.2 39.96,76.07 v2(39.75,75.87) 39.5,75.87 39.14,76.23 C2407.1 38.38,76.76 R2441.1 38.11,76.49 37.24,76.49 37.06,76.67 36.25,76.67 36.06,76.49 36.02,76.49 35.18,75.64 33.32,75.64 32.85,75.17 32.85,74.83 32.75,74.73 U2401.109
MSATA_DEVSLP_R: length 17.9
  TOP w0.089: v1(30.81,26.6) 30.81,26.98 36.77,32.95 v2(39.75,32.95) R6301.2
  BOTTOM w0.089: SSD1.38 27.2,26.04 27.33,26.17 28.81,26.17 28.81,26.16 29.17,26.16 29.17,26.17 30.39,26.17 v1(30.81,26.6)
MUX_CRT_AUX_CPU_N: length 1.4
  TOP w0.114: U5802.29 55.67,119.23 R5825.2
MUX_CRT_AUX_CPU_P: length 1.4
  TOP w0.114: R5824.2 56.05,119.2 55.96,119.2 55.59,118.83 U5802.28
MUX_HPD_PD: length 5.5
  TOP w0.089: U7101.23 22.6,109.52 23.35,110.26 23.88,110.26 24.11,110.03 24.85,110.03 R7118.1 v2(24.82,111.05)
MUX_SAI: length 1.5
  TOP w0.089: R7127.2 32.79,120.68 32.79,120.47 32.64,120.32 U7102.14
MUX_SAO: length 0.9
  TOP w0.089: R7129.2 32.24,120.71 U7102.15
MUX_SBI: length 4.7
  TOP w0.089: v2(37.24,121.25) 35.65,121.25 35.49,121.08 R7128.2 35.12,120.37 33.72,120.37 33.44,120.09 U7102.12
MUX_SBO: length 1.9
  TOP w0.089: R7130.2 35.31,120.14 34.16,120.14 U7102.11
N12P_JTAG_TCK: length 9.7
  BOTTOM w0.089: TP7903.1 118.21,128.52 118.21,129.17 119.52,130.48 119.72,130.48 120.5,131.26 120.5,131.62 119.78,132.35 119.78,132.7 119.94,132.86 119.94,133.28 119.8,133.41 119.8,133.81 120,134.01 120.5,134.01 121.37,133.14 GPU1.AE5
N12P_JTAG_TDI: length 1.6
  TOP w0.089: TP7905.1 122.72,133.74 v1(123.02,133.74)
  BOTTOM w0.089: GPU1.AE6 v1(123.02,133.74)
N12P_JTAG_TDO: length 1.7
  TOP w0.089: v1(121.91,133.76) 121.75,133.61 TP7901.1
  BOTTOM w0.089: 121.91,134.31 v1(121.91,133.76)
N12P_JTAG_TMS: length 2
  TOP w0.089: v1(122.45,133.18) 122.45,133.14 122.35,133.05 TP7902.1
  BOTTOM w0.089: GPU1.AD6 122.46,133.18 122.46,133.18 v1(122.45,133.18)
N12P_JTAG_TRST: length 10.7
  BOTTOM w0.089: R7944.1 116.67,127.92 v2(116.72,127.97) 117.3,127.97 117.58,127.69 118.16,127.69 118.6,128.13 118.6,129.29 119.24,129.93 120.27,129.93 121.04,130.7 121.04,131.01 120.93,131.11 120.93,131.6 121.07,131.73 121.07,132.25 120.14,133.18 GPU1.AG4
N12P_XTAL_OUTBUFF: length 15.6
  TOP w0.089: v2(137.35,122.04) 137.66,122.34 v1(137.66,122.61)
  L3 w0.089: v1(147.45,115.24) 140.31,122.38 137.89,122.38 v1(137.66,122.61)
  BOTTOM w0.089: R7902.1 R7917.2 147.68,115.01 v1(147.45,115.24) ; GPU1.C10 v1(137.66,122.61)
NB_MUTE#: length 75.7
  TOP w0.089: v2(32.05,17.44) 32.05,17.27 v1(31.74,16.97) ; v1(28.58,69.55) 28.18,69.95 28.18,71.95 28.85,72.62 28.85,73.24 28.76,73.33 U2401.119 ; v1(31.74,16.97) 32.03,16.68 R2712.1 ; v1(31.74,16.97) 31.65,16.87 R2717.2
  L3 w0.089: v1(25.99,26.62) 26.44,26.16 31.47,26.16 33.7,23.93 33.7,18.51 32.14,16.95 31.85,16.95 31.83,16.97 v1(31.74,16.97)
  L6 w0.089: v1(28.58,69.55) 28.44,69.68 27.73,69.68 24.01,65.96 24.01,61.45 20.53,57.98 20.53,53.52 21.37,52.69 21.37,51.36 20.86,50.86 20.86,42.95 21.41,42.41 21.41,36.61 21.83,36.18 21.83,27.68 23.17,26.35 25.43,26.35 25.71,26.62 v1(25.99,26.62)
NC_AUX_EN_WOWL_EC: length 14
  TOP w0.089: U2401.41 28.36,57.56 28.12,57.33 28.12,55.78 27.89,55.55 27.28,55.55 26.79,56.04 25.45,56.04 25.1,56.39 25.1,56.82 24.29,57.63 23.02,57.63 22.33,56.95 21.49,56.95 R2403.1 21.34,57.46 20.63,58.17 v2(20.22,58.17) R2409.1
NCT7718_DXN: length 95
  TOP w0.254: v2(120.53,119.76) 120.74,119.76 ; 120.74,119.76 120.74,118.78 120.88,118.64 120.88,118.55 C2607.2 121.16,118.26 U2601.3 ; 120.74,119.76 120.74,120.79 v1(122.18,122.23)
  L6 w0.254: v1(122.18,122.23) 122.36,122.23 122.42,122.28 122.84,122.28 124.64,120.48 124.64,118.24 129.39,113.49 129.39,111.25 130.79,109.84 130.79,106.76 131.62,105.93 131.62,105.09 131.32,104.78 131.32,90.3 131.65,89.97 131.65,77.4 133.07,75.97 v1(133.38,75.97)
  BOTTOM w0.254: v1(133.38,75.97) 133.51,75.85 159.87,75.85 160.53,76.5 165.17,76.5 166.73,78.06 C2606.2 166.73,79.59 Q2603.E
NCT7718_DXP: length 97.5
  TOP w0.254: v1(122.63,121.78) 122.45,121.78 121.25,120.58 121.25,119.47 C2607.1 121.81,118.53 U2601.2 ; v2(133,74.91) v1(133,75.46)
  L6 w0.254: v1(133,75.46) 132.86,75.46 131.14,77.18 131.14,89.76 130.81,90.09 130.81,105 131.11,105.3 131.11,105.72 130.29,106.55 130.29,109.63 128.88,111.04 128.88,113.28 124.13,118.03 124.13,120.27 v1(122.63,121.78)
  BOTTOM w0.254: v1(133,75.46) 133.17,75.46 133.29,75.34 160.08,75.34 160.74,75.99 165.38,75.99 C2606.1 167.77,78.94 167.77,79.76 167.83,79.83 Q2603.B 166.88,81.34 Q2603.C
NRB_BIT: length 92.8
  TOP w0.089: v1(156.11,58.19) 153.6,60.71 153.6,65.32 152.76,66.16 147.75,66.16 147.53,65.95 145.38,65.95 142.95,68.38 138.86,68.38 v2(138.74,68.51) 138.72,68.52 R1502.2
  L5 w0.089: v1(156.11,58.19) 128.19,58.19 120.93,65.46 120.93,66.24 109.58,77.58 109.58,84.54 108.55,85.56 108.55,88.07 v1(108.11,88.52)
  BOTTOM w0.089: CPU1.CE29 107.93,88.52 v1(108.11,88.52)
NUVOTON_PP: length 3.6
  TOP w0.089: TP9104.1 162.87,84.43 163.74,83.55 U9103.4
NVVDD_EN: length 8.2
  TOP w0.089: v1(98.3,146.79) 98.59,147.07 R8801.2 98.9,147.66 v2(98.3,148.26) 97.49,149.07 C8802.1 95.99,149.4 95.76,149.63 U8804.2
  BOTTOM w0.089: v1(98.3,146.79) 98.38,146.86 99.79,146.86 100,146.65 R8809.1
NVVDD_EN_1: length 3.5
  TOP w0.089: v2(96.77,147.88) 96.52,148.13 95.63,148.13 95.41,148.36 R8810.2 95.41,149.48 95.11,149.77 U8804.1
NXP3290_FO: length 21.2
  TOP w0.089: U7403.C4 41.75,122.17 41.75,121.7 41.3,121.24 40.21,121.24 v1(39.98,121.02) 39.98,121.02 R7402.1 ; U7201.23 41.33,108.21 41.54,107.99 42.37,107.99 v1(42.37,107.99) 42.96,108.59 v2(43.36,108.59)
  L5 w0.089: v1(42.37,107.99) 41.89,108.48 41.89,113.81 42.21,114.14 42.21,115.55 42.22,115.56 42.22,115.61 42.58,115.96 42.6,115.96 42.95,116.31 42.95,116.66 42.93,116.68 42.93,117.65 39.98,120.6 v1(39.98,121.02)
NXP3290_ILIM: length 3
  TOP w0.089: U7403.A3 43.16,123.06 43.5,122.72 43.5,122.43 43.5,122.42 43.5,121.74 v2(43.37,121.33) 43.37,121.33 R7418.1
NXP3290CAP: length 3.5
  TOP w0.089: U7403.D4 41.58,122.49 41.58,121.77 41.33,121.52 39.64,121.52 C7405.1
ODD_SATA_RX_CON_N: length 6.1
  TOP w0.114: C6010.2 187.95,39.55 187.83,39.68 187.83,40.1 188.65,40.92 AFTP6003.1 189.77,40.46 v1(190.33,40.46)
  BOTTOM w0.114: ODD1.4 190.2,39.8 190.33,39.93 v1(190.33,40.46)
ODD_SATA_RX_CON_P: length 6.3
  TOP w0.114: 187.6,39.68 187.6,40.48 187.47,40.61 186.68,40.61 185.83,39.75 185.78,39.75 v1(185.72,39.69) ; 187.6,39.68 187.6,39.58 187.86,39.32 188.01,39.32 188.12,39.22 188.12,38.89 188.22,38.79 C6011.2 ; 187.6,39.68 AFTP6004.1
  BOTTOM w0.114: v1(185.72,39.69) 186.11,39.3 ODD1.5
ODD_SATA_RX_N12: length 255.1
  TOP w0.114: v1(191.04,38.97) 191.04,39.39 190.91,39.52 190.73,39.52 190.49,39.28 189.83,39.28 C6010.1 ; v1(110.12,118.94) 110.99,118.94 112.21,120.16 115.52,120.16 115.73,119.94 117.94,119.94 118.07,119.81 118.07,119.63 v1(117.99,119.56)
  L5 w0.102: v1(191.04,38.97) 191.27,38.74 192.61,38.74 194.27,37.07 200.16,37.07 200.47,37.39 204.75,37.39 205.06,37.07 208.1,37.07 208.84,37.82 211.68,37.82 213.46,39.61 216.11,39.61 219.45,36.27 219.45,36.1 219.73,35.82 223.27,35.82 224.87,37.42 224.87,42.54 222.69,44.72 222.69,52.62 223.55,53.47 223.55,62.97 220.88,65.63 211.64,65.63 211.06,65.05 200.38,65.05 197.94,62.61 190,62.61 188.63,61.24 184.08,61.24 180.89,64.42 180.89,65.48 178.52,67.85 177.89,67.85 175.56,70.18 173.48,70.18 173.07,70.59 164.78,70.59 163.92,71.45 144.71,71.45 144.7,71.46 132.28,71.46 129.66,74.07 129.66,74.58 129.66,88.65 129.21,89.1 129.21,92.8 128.15,93.87 128.15,100.02 126.8,101.36 126.8,103.56 125.67,104.69 125.67,109.05 125.48,109.25 125.48,112.95 124.64,113.79 124.64,115 121.48,118.16 121.48,118.74 121.27,118.95 118.6,118.95 v1(117.99,119.56) ; v1(110.12,118.94) 105.19,118.94 101.73,115.48 101.73,105.79 100.41,104.47 100.41,103.22 v1(99.97,102.78)
  BOTTOM w0.114: v2(117.61,119.97) 117.99,119.58 v1(117.99,119.56) ; CPU1.BL6 v1(99.97,102.78)
ODD_SATA_RX_P12: length 255.1
  TOP w0.114: v1(110.12,119.57) 110.53,119.16 110.89,119.16 112.11,120.38 115.61,120.38 115.83,120.17 118.04,120.17 118.32,119.88 118.32,119.88 118.63,119.58 v1(118.63,119.55) ; C6011.1 189.83,39.05 190.2,39.05 v1(190.42,38.84)
  L5 w0.102: v1(99.97,103.48) 100.21,103.72 100.21,104.56 101.53,105.88 101.53,115.56 105.1,119.14 109.69,119.14 v1(110.12,119.57) ; v1(118.63,119.55) 118.63,119.32 118.79,119.15 121.35,119.15 121.68,118.82 121.68,118.25 124.84,115.09 124.84,113.88 125.68,113.04 125.68,109.33 125.87,109.14 125.87,104.77 127,103.64 127,101.45 128.35,100.1 128.35,93.96 129.42,92.89 129.42,89.19 129.87,88.74 129.87,74.49 129.87,74.16 132.36,71.66 144.79,71.66 144.8,71.65 164.01,71.65 164.87,70.8 173.16,70.8 173.57,70.39 175.65,70.39 177.98,68.06 178.6,68.06 181.1,65.56 181.1,64.51 184.16,61.44 188.55,61.44 189.92,62.82 197.85,62.82 200.29,65.25 210.98,65.25 211.56,65.84 220.97,65.84 223.75,63.05 223.75,53.39 222.89,52.53 222.89,44.8 225.07,42.62 225.07,37.33 223.35,35.61 219.65,35.61 219.24,36.01 219.24,36.18 216.02,39.4 213.55,39.4 211.76,37.62 208.93,37.62 208.18,36.87 204.97,36.87 204.66,37.18 200.55,37.18 200.24,36.87 194.19,36.87 192.53,38.53 190.72,38.53 v1(190.42,38.84)
  BOTTOM w0.114: CPU1.BL5 v1(99.97,103.48) ; v1(118.63,119.55) 118.63,119.45 v2(118.98,119.1)
ODD_SATA_TX_CON_N: length 11.4
  TOP w0.114: 191.68,41.96 191.68,41.65 191.98,41.35 191.98,40.34 C6013.2 ; 191.68,41.96 AFTP6002.1 ; 191.68,41.96 191.68,42.42 191.57,42.53 191.29,42.53 190.83,42.06 188.93,42.06 188.57,41.71 188.57,41.54 188.69,41.43 189.95,41.43 190.11,41.59 190.11,41.59 190.12,41.59 190.52,41.59 v1(190.99,41.12)
  BOTTOM w0.114: v1(190.99,41.12) 190.52,41.59 190.12,41.59 190.11,41.59 190.11,41.59 189.32,40.8 ODD1.2
ODD_SATA_TX_CON_P: length 11.4
  TOP w0.114: v1(185.68,40.96) 186.35,41.63 AFTP6001.1 187.73,41.33 188.08,41.33 188.26,41.51 188.26,41.72 188.83,42.29 190.73,42.29 191.2,42.76 191.66,42.76 191.91,42.51 191.91,41.75 192.21,41.45 192.21,40.36 C6014.2
  BOTTOM w0.114: v1(185.68,40.96) 186.02,41.3 ODD1.1
ODD_SATA_TX_N12: length 256.5
  TOP w0.114: v1(117.75,121.09) 117.53,120.86 116.22,120.86 115.95,121.13 111.38,121.13 110.89,120.64 110.35,120.64 v1(110.13,120.86) ; C6013.1 v1(191.31,38.08)
  L5 w0.102: v1(110.13,120.86) 109.89,120.63 108.84,120.63 108.68,120.78 104.95,120.78 100.74,116.56 100.74,112.6 100.61,112.47 v1(100.41,112.47) ; v1(191.31,38.08) 191.65,37.74 191.65,37.18 192.56,36.26 200.49,36.26 200.8,36.57 204.36,36.57 204.67,36.26 208.43,36.26 209.18,37.01 212.03,37.01 212.4,37.37 212.4,37.39 213.7,38.69 215.87,38.69 218.06,36.5 218.06,36.04 219.17,34.93 223.9,34.93 225.68,36.7 225.68,42.98 223.5,45.16 223.5,52.28 224.36,53.14 224.36,63.32 221.03,66.65 211.44,66.65 210.75,65.97 200.03,65.97 197.54,63.48 189.61,63.48 188.24,62.1 184.36,62.1 181.71,64.76 181.71,66.05 179.03,68.73 178.16,68.73 175.71,71.18 173.89,71.18 173.66,71.41 165.12,71.41 164.26,72.26 145.05,72.26 145.04,72.27 132.61,72.27 130.48,74.41 130.48,89.47 130.03,89.92 130.03,93.37 129.13,94.27 129.13,100.18 128.32,100.99 128.32,103.72 126.62,105.42 126.62,109.47 126.37,109.73 126.37,113.32 125.79,113.91 125.79,115.05 122.39,118.46 122.39,119.19 120.48,121.1 119.47,121.1 118.94,121.64 118.3,121.64 v1(117.75,121.09)
  BOTTOM w0.076: 99.67,108.86 99.67,108.76 99.7,108.74 99.7,108.51 100.06,108.15 100.06,106.21 100.35,105.92 CPU1.BN2
  BOTTOM w0.114: v1(100.41,112.47) 100.33,112.47 99.67,111.82 99.67,111.13 ; v2(99.52,111.13) 99.67,111.13 ; 99.67,111.13 99.67,108.86
ODD_SATA_TX_P12: length 256.4
  TOP w0.114: v1(191.98,38.1) 191.79,38.28 191.79,38.46 191.92,38.59 192.55,38.59 192.71,38.76 192.71,38.94 C6014.1 ; v1(118.2,120.64) 116.13,120.64 115.86,120.91 111.48,120.91 110.98,120.41 110.32,120.41 v1(110.13,120.23)
  L5 w0.102: v1(118.2,120.64) 118.41,120.84 118.41,120.94 118.24,121.11 118.24,121.29 118.39,121.43 118.86,121.43 119.39,120.9 120.39,120.9 122.18,119.11 122.18,118.37 125.58,114.97 125.58,113.82 126.16,113.24 126.16,109.64 126.42,109.39 126.42,105.34 128.12,103.64 128.12,100.91 128.93,100.1 128.93,94.18 129.82,93.29 129.82,89.83 130.27,89.38 130.27,74.33 132.53,72.07 144.96,72.07 144.97,72.06 164.18,72.06 165.03,71.2 173.58,71.2 173.8,70.98 175.63,70.98 178.08,68.53 178.94,68.53 181.5,65.97 181.5,64.68 184.28,61.9 188.33,61.9 189.7,63.27 197.62,63.27 200.11,65.76 210.84,65.76 211.52,66.45 220.94,66.45 224.16,63.23 224.16,53.22 223.3,52.36 223.3,45.07 225.48,42.89 225.48,36.79 223.82,35.13 219.26,35.13 218.27,36.12 218.27,36.59 215.96,38.89 213.61,38.89 212.19,37.48 212.19,37.46 211.95,37.21 209.1,37.21 208.35,36.46 204.75,36.46 204.44,36.78 200.72,36.78 200.41,36.46 192.65,36.46 191.85,37.26 191.85,37.47 191.98,37.59 192.19,37.59 192.32,37.72 192.32,37.96 192.18,38.1 v1(191.98,38.1) ; v1(100.41,111.84) 100.94,112.37 100.94,116.48 105.04,120.57 108.6,120.57 108.75,120.42 109.93,120.42 v1(110.13,120.23)
  BOTTOM w0.076: CPU1.BN1 100.23,106.6 100.23,108.23 99.88,108.58 99.88,108.81 99.9,108.84 99.9,108.86
  BOTTOM w0.114: 99.9,109.42 99.9,111.72 100.13,111.95 100.29,111.95 v1(100.41,111.84) ; 99.9,109.42 99.9,108.86 ; 99.9,109.42 v2(100.05,109.42)
OUT1_CA_DET: length 6.1
  TOP w0.089: U5802.43 v1(49.7,120.99)
  L6 w0.089: v1(49.7,120.99) 50.86,120.99 50.89,120.97 v1(53.22,120.97)
  BOTTOM w0.089: R5818.1 52.48,120.12 v2(52.48,120.85) 52.59,120.97 v1(53.22,120.97)
OUT2_CA_DET: length 2.6
  TOP w0.089: v1(53.85,120.96) 53.85,120.96 53.7,120.81 U5802.33
  BOTTOM w0.089: v2(54.11,121.46) v1(53.85,120.96) 53.85,120.96 53.47,120.58 R5819.1
OVERT_GPU#: length 15.4
  BOTTOM w0.089: v2(136,106.03) 136,106.08 136.93,107.01 RN7910.1 136.93,107.51 137.25,107.84 137.25,108.14 138.01,108.9 138.01,114.82 136.25,116.57 136.25,117.89 136.47,118.11 GPU1.A6
PANEL_BKEN: length 242
  TOP w0.089: v1(20.2,41.98) v2(19.56,42.17) ; v1(224.41,37.6) 224.3,37.49 RN5502.1 223.22,37.95 223.09,38.08 RN5503.4
  L6 w0.089: v1(20.2,41.98) 20.21,41.98 21.05,41.13 21.05,36.1 21.39,35.76 21.39,27.59 23.11,25.87 34.25,25.87 36.73,28.34 39.42,28.34 41.18,30.1 88.95,30.1 90.54,31.69 104.16,31.69 109.1,36.63 109.1,38.53 109.97,39.4 109.97,40.47 112.58,43.08 124.1,43.08 128.17,39.02 129.03,39.02 129.67,38.38 140.35,38.38 145.45,33.28 153.85,33.28 154.89,32.24 175.43,32.24 176.41,31.27 186.92,31.27 190.15,34.49 191.87,34.49 192.86,33.51 198.84,33.51 201.3,35.97 208.38,35.97 209.3,36.89 214.98,36.89 215.97,35.89 217.61,35.89 218.47,35.03 221.84,35.03 v1(224.41,37.6)
  BOTTOM w0.089: D2401.3 21.39,41.98 v1(20.2,41.98)
PANEL_BKEN_EC: length 43.2
  TOP w0.089: v1(20.24,41.34) v2(18.76,41.24) ; U2401.117 29.56,72.3 29.26,72.01 v1(29.26,70.61)
  L3 w0.089: v1(20.24,41.34) 20.86,41.96 20.86,50.73 21.46,51.33 21.46,53.26 22.09,53.89 22.09,55.18 21.62,55.65 21.62,56.81 23.99,59.17 24.62,59.17 25.55,60.1 25.97,60.1 26.34,60.47 26.34,63.9 25.82,64.41 25.82,66.23 25.69,66.36 25.69,67.26 25.89,67.45 25.89,67.7 27.01,68.83 28.46,68.83 29.07,69.43 29.07,70.42 v1(29.26,70.61)
  BOTTOM w0.089: v1(20.24,41.34) 21.17,41.34 22.29,40.22 D2401.1
PANEL_MONITOR: length 23.1
  TOP w0.089: R5545.1 47.09,67.26 48.39,68.56 48.39,69.27 51.06,71.94 51.06,73.19 49.85,74.41 v1(49.81,74.41) ; U2401.97 38.44,73.91 v1(38.89,74.37) 38.85,75.01 v2(38.74,75.11)
  BOTTOM w0.089: v1(38.89,74.37) 39.16,74.63 42.9,74.63 42.9,74.63 43.25,74.63 43.48,74.4 49.81,74.4 v1(49.81,74.41)
PANEL_PWRGD_R: length 14
  TOP w0.089: Q5505.3 47.26,64.61 R5547.1 47.2,65.08 C5529.1 47.7,65.13 v2(47.7,65.97) 47.7,66.45 47.96,66.7 R5545.2 48.9,65.99 R5549.2 49.96,65.39 49.96,64.87 50.24,64.59 50.24,63.27 50.7,62.82 50.7,62.26 51.44,61.52 Q5504.3
PBAT_CHG_SMBCLK: length 266.8
  TOP w0.114: EC4309.1 134.74,37.05 135.42,37.05 135.94,36.53 v1(135.94,36.45) 136.83,36.45 137.33,36.95 RN4302.2 ; v1(207.07,48.75) v2(207.93,48.69) ; v1(20.86,68.42) 21.71,69.27 RN2402.3 21.99,69.27 22.34,68.93 22.75,68.93 23.11,69.29 U2401.9
  L5 w0.114: v1(135.94,36.45) 136.67,37.18 141.56,37.18 142.72,36.02 147.66,36.02 148.56,35.12 149.98,35.12 150.59,35.73 165.83,35.73 166.6,36.51 168.29,36.51 169.67,37.89 173.96,37.89 174.6,38.52 174.62,38.52 175.3,38.52 175.3,38.52 181.79,38.52 185.13,41.86 187.12,41.86 189.01,43.76 191.16,43.76 192.71,42.2 196.13,42.2 196.18,42.25 200.4,42.25 203.2,45.06 203.97,45.06 204.3,45.39 204.3,46.89 205.27,47.87 205.27,48.19 205.97,48.88 205.97,49.02 206.22,49.28 206.59,49.28 206.84,49.02 206.84,49.02 207.07,48.79 v1(207.07,48.75)
  L6 w0.114: v1(135.94,36.45) 135.33,37.06 128.3,37.06 125.47,39.89 124.66,39.89 124.61,39.83 v1(124.16,39.83) 122.19,41.8 113.05,41.8 111.92,40.66 111.92,34.85 107.42,30.35 107.42,30 106.41,28.98 98.2,28.98 97.2,29.98 91.3,29.98 89.57,28.25 45.58,28.25 45.28,27.95 40.85,27.95 37.52,24.61 22.57,24.61 20.02,27.17 20.02,35.18 18.51,36.69 18.51,58.67 18.51,58.67 18.51,59.17 20.15,60.8 20.15,66.4 20.15,66.4 20.15,66.66 20.86,67.36 v1(20.86,68.42)
  BOTTOM w0.114: v1(207.07,48.75) 206.66,48.34 206.31,48.34 206.29,48.36 206.13,48.36 206.05,48.44 PU4401.22 ; v1(124.16,39.83) 124.16,40.76 124.29,40.89 ED4306.3
PBAT_CHG_SMBDAT: length 264.2
  TOP w0.114: RN4302.3 v1(137.54,36.45) 137.27,36.17 136.28,36.17 136.13,36.01 134.93,36.01 EC4310.1 ; RN2402.4 22.11,69.92 22.56,69.47 v1(22.56,69.37) 22.88,69.69 U2401.8 ; v2(128.81,38.28) v1(128.53,37.64)
  L5 w0.114: v1(137.54,36.45) 137.74,36.25 142.14,36.25 142.6,35.78 147.56,35.78 148.46,34.88 150.08,34.88 150.69,35.49 165.43,35.49 165.43,35.49 165.93,35.49 166.7,36.27 168.39,36.27 169.77,37.64 174.06,37.64 174.7,38.28 174.72,38.28 175.2,38.28 175.2,38.28 181.89,38.28 185.23,41.62 187.22,41.62 189.11,43.52 191.06,43.52 192.61,41.96 196.23,41.96 196.28,42.01 200.5,42.01 203.3,44.82 204.07,44.82 204.54,45.29 204.54,46.79 205.51,47.77 205.51,47.81 206.4,48.7 206.4,48.76 v1(206.43,48.78)
  L6 w0.114: v1(22.56,69.37) 22.56,68.76 20.37,66.57 20.37,60.72 18.73,59.08 18.73,58.76 18.73,58.76 18.73,36.85 20.26,35.32 20.26,27.29 22.72,24.83 37.43,24.83 40.76,28.16 45.19,28.16 45.49,28.47 89.48,28.47 91.23,30.21 97.96,30.21 98.87,29.3 106.42,29.3 107.2,30.09 107.2,30.44 111.7,34.94 111.7,40.75 112.96,42.01 113.14,42.01 113.14,42.01 123.65,42.01 128.02,37.64 v1(128.53,37.64) 128.9,37.28 136.71,37.28 v1(137.54,36.45)
  BOTTOM w0.114: PU4401.21 206.37,48.84 v1(206.43,48.78) ; ED4305.3 129.65,37.36 129.37,37.64 v1(128.53,37.64)
PBAT_PRES1#: length 6.5
  TOP w0.089: 140.21,35.23 v1(140.34,35.23) ; 140.21,35.23 139.58,35.86 RN4302.5 ; 140.21,35.23 139.83,34.85 AFTP4309.1
  BOTTOM w0.089: v1(140.34,35.23) 140.21,35.23 139.07,36.37 BATT1.6
PBAT_PRES#: length 255.8
  TOP w0.089: v1(21.72,60.25) 22.28,60.81 22.28,61.11 22.46,61.29 U2401.29 ; EC4306.2 135.11,35.08 v2(135.47,35.08) 135.87,35.08 v1(136.02,35.23) 136.65,35.86 RN4302.4 ; v1(204.97,45.48) 204.97,44.69 205.13,44.53 PR4409.2
  L5 w0.089: v1(21.72,60.25) 21.22,60.25 17.83,56.86 17.83,50.25 17.42,49.83 17.42,36.36 17.9,35.88 17.9,32.64 22.27,28.27 29.42,28.27 29.48,28.33 29.63,28.33 30.7,28.33 35.48,33.11 35.5,33.11 52.56,33.11 54.39,34.95 93.21,34.95 93.85,35.58 99.65,35.58 101.07,34.16 101.5,34.16 103.03,35.69 106,35.69 106.99,36.69 106.99,37.45 107.61,38.06 107.61,41.71 108.65,42.75 110.31,42.75 111.6,44.04 126.66,44.04 v1(129.47,41.23) ; v1(204.97,45.48) 204.97,45.13 203.48,43.64 202.45,43.64 200.59,41.78 197.82,41.78 197.16,41.12 197,41.12 196.9,41.03 196.55,41.03 196.45,41.12 196.19,41.12 195.58,41.73 191.97,41.73 191.54,42.17 189.52,42.17 188.05,40.7 188.05,39.7 188.05,39.31 186.8,38.05 175.11,38.05 174.79,38.05 174.16,37.42 169.87,37.42 168.49,36.04 166.8,36.04 166.02,35.26 165.99,35.26 150.79,35.26 150.17,34.65 148.37,34.65 147.46,35.55 142.5,35.55 142.04,36.02 136.81,36.02 v1(136.02,35.23)
  BOTTOM w0.089: R2415.1 21.59,60.38 v1(21.72,60.25) ; 129.78,38.19 130.51,37.47 131.83,37.47 134.06,35.23 v1(136.02,35.23) ; 129.78,38.19 127.07,38.19 126.83,37.94 125.4,37.94 ED4304.3 ; 129.78,38.19 129.97,38.37 129.97,40.73 v1(129.47,41.23)
PBAT_SMBCLK1: length 9.3
  TOP w0.114: RN4302.7 139.89,36.95 140.24,37.29 141.05,37.29 141.64,36.7 AFTP4311.1 142.57,36.23 141.61,35.26 v1(141.61,35.21)
  BOTTOM w0.114: BATT1.4 141.58,35.24 v1(141.61,35.21)
PBAT_SMBDAT1: length 7.6
  TOP w0.114: RN4302.6 140.16,36.45 AFTP4310.1 141.23,36.34 141.23,35.61 140.97,35.36 v1(140.97,35.21)
  BOTTOM w0.114: v1(140.97,35.21) 140.97,35.36 140.33,36.01 BATT1.5
PC10: length 3.2
  TOP w0.089: R5808.2 R5807.2 44.27,116.99 44.8,117.53 v2(45.31,117.53) 45.41,117.63 U5802.56
PC11: length 2
  TOP w0.089: R5811.2 44.6,118.03 U5802.55
PC20: length 3
  TOP w0.089: U5802.54 45.61,118.43 v2(45.29,118.75) 45.01,118.75 44.88,118.62 R5810.2 44.5,118.72 R5809.2
PC21: length 3.7
  TOP w0.089: R5814.2 44.53,120.19 R5813.2 44.5,120.12 44.91,119.71 44.91,119.25 45.06,119.1 45.55,119.1 45.82,118.83 U5802.53
PCH_BATLOW#: length 50.7
  TOP w0.089: RN1704.8 142.12,69.7 v1(142.29,69.52) v2(141.91,69.11)
  BOTTOM w0.089: CPU1.BV36 103.83,83.8 104.53,83.09 104.53,81.34 105.67,80.2 105.67,79.02 105.95,78.75 105.95,76.77 111.77,70.94 111.92,70.94 112.07,70.94 114.99,70.94 114.99,70.94 115.91,70.94 118.52,68.33 132.15,68.33 132.39,68.09 138.65,68.09 140.69,70.12 141.69,70.12 v1(142.29,69.52)
PCH_ESPI_CLK: length 11.6
  TOP w0.114: v1(104.45,87.17) 104.45,86.69 104.42,86.67 104.42,81.05 103.79,80.42 v2(103.79,77.24) R1805.1
  BOTTOM w0.114: v1(104.45,87.17) 104.45,87.17 104.44,87.13 CPU1.BV32
PCH_ESPI_IO0: length 13.2
  TOP w0.114: RN1806.1 106.33,86.19 106.69,86.55 106.69,87.17 106.78,87.27 v2(106.78,87.58) 106.78,87.94 106.45,88.27 106.45,88.38 106.3,88.54 v1(106.27,88.54)
  BOTTOM w0.114: v1(106.27,88.54) 106.27,88.55 CPU1.CA29
PCH_ESPI_IO1: length 13.1
  TOP w0.076: v1(105.32,88.45) 105.01,88.14 105.01,87.68 105,87.67 105,86.13 104.98,86.11
  TOP w0.114: RN1806.3 v2(105.24,77.29) 105.24,80.8 105.41,80.98 105.41,85.34 104.98,85.78 104.98,86.11
  BOTTOM w0.114: v1(105.32,88.45) 105.31,88.47 104.95,88.67 CPU1.BY29
PCH_ESPI_IO2: length 14.4
  TOP w0.114: v1(105.37,89.81) 105.37,89.68 105.84,89.21 105.84,86.95 105.94,86.85 v2(105.94,86.67) 105.94,80.88 105.74,80.68 RN1806.2
  BOTTOM w0.114: CPU1.BY27 v1(105.37,89.81)
PCH_ESPI_IO3: length 15
  TOP w0.076: v2(103.97,89.49) 104.12,89.49 v1(104.44,89.8) 104.87,89.38 104.87,88.6 104.85,88.58 104.85,87.75 104.84,87.74 104.84,86.55 104.7,86.41
  TOP w0.114: RN1806.4 104.65,80.52 104.83,80.7 104.83,85.47 104.7,85.6 104.7,86.41
  BOTTOM w0.114: v1(104.44,89.8) 104.14,90.1 CPU1.BV27
PCH_JTAG_TCK: length 17.6
  TOP w0.114: v1(66.8,100.89) 66.58,100.66 FC8983.1 v2(66.2,101.55)
  L6 w0.114: v1(79.69,103.36) 79.67,103.35 79.26,102.94 79.26,102.59 77.84,101.17 74.6,101.17 73.93,100.5 69.57,100.5 69.18,100.89 v1(66.8,100.89)
  BOTTOM w0.114: CPU1.W6 79.46,103.14 79.67,103.35 v1(79.69,103.36) ; v1(66.8,100.89) R318.1
PCH_JTAG_TDI: length 12.9
  BOTTOM w0.114: R312.1 72.39,112.02 v2(72.39,110.92) 72.39,110.01 75.54,106.86 75.54,105.8 75.82,105.52 76.04,105.52 76.24,105.32 76.24,104.41 76.51,104.14 77.95,104.14 CPU1.U5
PCH_JTAG_TDO: length 13.1
  BOTTOM w0.114: R313.1 78.11,112.83 76.97,111.69 v2(76.84,111.69) 76.2,111.05 76.2,109.27 76.62,108.86 78.4,108.86 79.45,107.81 79.45,107.02 79.38,106.95 79.38,106.07 79.15,105.84 78.95,105.84 78.74,105.63 78.74,104.28 CPU1.W5
PCH_JTAG_TMS: length 11.5
  BOTTOM w0.114: CPU1.P5 76.11,104.14 75.63,104.14 75.08,104.69 75.08,104.98 75.08,104.99 75.08,106.88 71.96,110.01 v2(71.96,112.06) 72.52,112.62 R314.1
PCH_PLTRST#: length 88.2
  TOP w0.089: v1(157.48,77.47) 156.26,77.47 153.94,75.15 v2(153.94,74.66) 153.65,74.37 153.65,68.4 155.74,66.31 156.14,66.31 v1(156.57,65.89)
  BOTTOM w0.089: R1713.2 158.37,78.36 v1(157.48,77.47) ; CPU1.BJ35 98.44,84.85 98.44,83.8 99.44,82.8 99.44,81.57 100.11,80.91 100.23,80.91 101.26,79.88 101.26,77.05 112.55,65.76 123.24,65.76 123.99,66.51 125.77,66.51 126.22,66.07 126.22,65.48 126.43,65.27 127.05,65.27 128.03,66.26 153.76,66.26 154.56,65.46 156.14,65.46 v1(156.57,65.89)
PCH_POPIRCOMP: length 1.5
  TOP w0.114: v1(104.6,90.63) 105.36,90.63 R305.1
  BOTTOM w0.114: CPU1.BW25 104.6,90.7 v1(104.6,90.63)
PCH_RSMRST#: length 298.4
  TOP w0.089: v1(87.71,41.56) 87.39,41.88 86.38,41.88 84,39.5 84,37 v2(83.85,36.84) v1(83.28,36.84) ; R1702.2 156.08,70.47 EC1712.1 155.58,69.94 155.58,69.39 155.9,69.06 156.99,69.06 157.43,68.62 157.43,68.3 158.42,67.31 158.42,63.1 159.75,61.77 160.87,61.77 164.5,58.14 165.96,58.14 166.75,57.35 v1(166.75,56.74) ; R6414.2 52.1,66.96 57.63,61.43 v1(100.06,61.43) 100.08,61.44 105.92,61.44 113.35,68.87 v1(113.35,69.79) ; v1(25.48,61.8) 25.19,62.09 U2401.27
  L5 w0.089: v1(83.28,36.84) 82.91,36.48 76.85,36.48 76.03,35.66 54.1,35.66 54.08,35.64 53.47,35.64 53.24,35.87 52.32,35.87 52.05,35.59 52.05,34.22 51.71,33.88 37.44,33.88 37.34,33.99 36.61,34.72 35.4,34.72 34.95,34.26 34.95,33.84 32.84,31.73 29.04,31.73 26.47,29.16 22.64,29.16 19.57,32.24 19.57,35.62 18.31,36.88 18.31,49.43 19.08,50.19 19.08,55.48 23.85,60.25 24.74,60.25 25.28,60.79 25.28,61.6 v1(25.48,61.8) ; v1(166.75,56.74) 166.07,56.07 127.59,56.07 118.49,65.16 118.49,66.24 115.92,68.81 114.33,68.81 v1(113.35,69.79)
  L6 w0.089: v1(87.71,41.56) 88.11,41.16 89.72,41.16 91.29,42.72 101.25,42.72 102.42,43.89 102.42,49.76 100.06,52.11 v1(100.06,61.43)
PCH_SMBCLK: length 227.5
  TOP w0.114: v1(175.01,49.38) 175.44,49.38 176.94,50.88 176.94,53.47 179.43,55.96 192.21,55.96 192.54,56.29 194.13,56.29 194.74,56.9 196.64,56.9 196.95,57.21 v1(196.95,57.82) 197.32,58.19 FC9001.1 ; v1(173.3,74.28) 173.3,71.85 174.37,70.79 174.37,67.79 173.5,66.92 173.5,63.8 173.62,63.68 173.62,62.5 v1(173.05,61.93)
  L5 w0.114: v1(173.3,74.28) 173.21,74.19 173.21,73.18 172.26,72.23 169.41,72.23 168.78,72.86 166.76,72.86 166.58,73.04 161.68,73.04 161.55,73.17 161.53,73.17 160.46,74.25 158.15,74.25 158.02,74.12 131.93,74.12 130.89,75.16 130.89,90.03 130.59,90.33 130.59,95.02 v1(130.18,95.43) ; v1(96.07,48.59) 96.07,47.73 97.72,46.08 97.99,46.08 98.28,45.79 102.64,45.79 104.28,44.15 104.66,44.15 105.01,44.5 109.85,44.5 110.92,45.58 129.91,45.58 131.67,43.82 132.06,43.82 132.79,43.08 162.11,43.08 163.99,41.19 168.17,41.19 168.26,41.19 168.28,41.22 169.13,42.07 169.69,42.07 170.22,42.07 170.22,42.07 170.35,42.07 172.11,43.84 172.11,47.12 174.37,49.38 v1(175.01,49.38)
  L6 w0.114: v1(173.05,61.93) 173.05,61.13 173.94,60.24 173.94,55.38 174.88,54.43 174.88,51.15 175.47,50.56 175.47,49.84 v1(175.01,49.38)
  BOTTOM w0.114: DM2.253 171.53,49.43 171.76,49.19 174.82,49.19 v1(175.01,49.38) ; DM1.253 95.33,49.33 v1(96.07,48.59) ; VGABD1.16 v1(196.95,57.82) ; Q1801.4 127.57,97.18 127.87,96.88 127.87,96.35 128.19,96.02 RN1810.3 129.08,95.43 v1(130.18,95.43) 130.58,95.43 v2(131.49,94.53) 131.73,94.28 132.64,94.28 133.18,93.74 U7001.1
PCH_SMBDATA: length 233.5
  TOP w0.114: v1(172.85,74.73) 172.85,73.71 172.93,73.64 172.93,71.88 174.12,70.69 174.12,68.07 173.26,67.21 173.26,63.7 173.38,63.58 173.38,63.07 v1(173.05,62.74) ; v1(196.47,57.35) 196.47,58 196.21,58.26 195.85,58.26 195.59,58 195.59,57.62 195.33,57.36 194.52,57.36 193.95,56.79 192.38,56.79 192.02,56.42 179.23,56.42 176.48,53.67 176.48,52.07 175.03,50.62 v1(175.03,50.38)
  L5 w0.114: v1(96.08,45.07) 97.93,45.07 98.24,45.38 102.68,45.38 104.15,43.91 104.88,43.91 105.23,44.26 109.95,44.26 111.02,45.33 127.82,45.33 130.05,43.11 132.39,43.11 132.82,42.67 162.17,42.67 163.89,40.95 168.27,40.95 168.36,40.95 168.38,40.98 169.23,41.83 169.79,41.83 170.32,41.83 170.32,41.83 170.45,41.83 172.37,43.75 172.37,47.03 173.93,48.59 174.84,48.59 175.45,49.2 175.45,49.96 v1(175.03,50.38) ; v1(130.2,96.97) 130.83,96.34 130.83,92.65 131.13,92.35 131.13,75.35 132.12,74.36 157.92,74.36 158.06,74.5 160.56,74.5 161.78,73.28 166.68,73.28 166.86,73.1 168.88,73.1 169.51,72.47 172.02,72.47 172.85,73.3 v1(172.85,74.73)
  L6 w0.114: v1(173.05,62.74) 172.61,62.3 172.61,61.26 173.72,60.15 173.72,55.29 174.63,54.38 174.63,50.78 v1(175.03,50.38)
  BOTTOM w0.114: Q1801.1 125.32,95.88 125.68,96.24 125.68,97.18 126.05,97.54 127.16,97.54 127.64,97.54 RN1810.4 128.98,97.18 130,97.18 130.2,96.98 v1(130.2,96.97) 131.35,95.83 v2(131.75,95.83) 132.83,95.83 U7001.4 ; DM2.254 171.76,42.92 171.76,45.76 174.5,48.5 174.75,48.5 175.45,49.2 175.45,49.96 v1(175.03,50.38) ; VGABD1.17 196.45,58.19 196.47,58.17 v1(196.47,57.35) ; v1(96.08,45.07) 95.58,44.57 DM1.254
PCH_TPAN_VDD_EN: length 88.3
  TOP w0.089: v1(127.49,80.98) 127.99,81.48 127.99,85.93 128.85,86.79 128.85,92.91 128.55,93.21 128.55,97.72 129.01,98.18 129.01,101.15 129.57,101.71 129.72,101.71 130.12,102.11 130.12,104.88 129.35,105.66 129.35,107.07 v1(129.75,107.47) ; v1(155.46,105.91) 155.53,105.84 R5559.1
  L3 w0.089: v1(107.19,88.49) 106.76,88.06 106.76,86.67 106.65,86.56 106.65,85.83 107.43,85.05 107.98,85.05 108.13,85.21 114.34,85.21 117.53,82.02 117.53,79.35 118.19,78.69 119.81,78.69 121.49,80.37 v1(122.3,80.37)
  L5 w0.089: v1(129.75,107.47) 130.96,108.68 132.17,108.68 132.26,108.59 133.94,108.59 135.11,107.42 136.05,107.42 137.32,108.69 151.87,108.69 152.15,108.97 153.19,108.97 153.77,108.38 153.77,108.18 155.39,106.57 155.39,105.98 v1(155.46,105.91)
  BOTTOM w0.089: v1(107.19,88.49) 106.85,88.15 CPU1.CC30 ; v1(127.49,80.98) 127.26,81.21 v2(125.45,81.21) 124.16,81.21 123.54,80.59 122.53,80.59 v1(122.3,80.37)
PCH_WAKE#: length 247.5
  TOP w0.089: v1(158.69,57.82) 157.36,59.16 156.57,59.16 153.77,61.95 153.77,65.4 152.83,66.34 147.67,66.34 147.46,66.13 145.45,66.13 143.03,68.56 141.72,68.56 140.95,69.33 140.95,69.8 141.03,69.88 RN1704.6
  L5 w0.089: v1(103.53,88.49) 103.96,88.92 103.96,89.93 102.89,91 102.1,91 101.94,90.84 101.1,90.84 100.49,91.46 100.49,92.32 97.36,95.45 97.36,98.31 96.44,99.23 86.86,99.23 86.34,98.71 74.4,98.71 73.36,97.66 67.82,97.66 v1(67.58,97.42) 67.01,96.85 60.1,96.85 57.95,94.71 56.18,94.71 54.95,93.47 54.95,91.55 v1(52.56,89.16)
  L6 w0.089: v1(60.2,74.22) 60.84,74.86 60.84,78.6 64.33,82.09 64.33,86.43 63.66,87.11 63.66,88.2 64.28,88.82 64.28,89.65 64.4,89.78 65.54,89.78 69.69,93.92 69.69,94.65 69.49,94.85 68.61,94.85 67.58,95.87 v1(67.58,97.42) ; v1(103.53,88.49) 104.02,88.01 104.02,86.9 104.3,86.62 104.3,82.45 116.12,70.63 116.12,70.06 129.08,57.09 157.96,57.09 v1(158.69,57.82)
  BOTTOM w0.089: D1702.3 v2(51.79,86.33) 52.07,86.62 52.07,88.67 v1(52.56,89.16) ; v1(60.2,74.22) 59.69,73.71 55.07,73.71 52.69,71.33 51.62,71.33 51.43,71.52 51,71.52 50.85,71.38 49.4,71.38 49.2,71.57 48.21,71.57 47.55,72.23 39.06,72.23 38.61,71.78 37.58,71.78 36.89,71.09 35.44,71.09 34.39,70.04 34.39,69.43 32.84,67.87 32.21,67.87 30,65.66 29.62,65.66 27.8,63.84 26.31,63.84 25.96,64.19 24.67,64.19 24.57,64.28 22.05,64.28 21.26,63.5 21.26,63.33 20.82,62.89 19.6,62.89 19.45,63.04 19.24,63.04 19.05,63.22 18.39,63.22 18.22,63.05 18.22,62.01 18.25,61.98 18.25,61.98 18.62,61.6 R2428.1 ; v1(103.53,88.49) 103.19,88.15 CPU1.BU30
PCIE_LAN_WAKE#: length 9.8
  TOP w0.089: U3101.21 48.47,83.74 48.53,83.67 v1(49.26,83.67) 49.58,83.67 R3103.1
  BOTTOM w0.089: v2(52.05,79.21) 52.05,80.24 D2404.1 D1702.1 51.29,83.92 49.61,83.92 49.36,83.67 v1(49.26,83.67)
PCIE_RCOMPN: length 2.9
  TOP w0.089: v1(108.26,102.81) 108.89,103.44 108.89,104.54 R1604.1
  BOTTOM w0.089: CPU1.CE6 107.87,103.1 108.19,102.81 v1(108.26,102.81)
PCIE_RCOMPP: length 2.4
  TOP w0.089: v1(108.26,103.46) 108.33,103.39 108.46,103.39 108.62,103.55 108.62,104.46 R1604.2
  BOTTOM w0.089: CPU1.CE5 108.26,103.46 v1(108.26,103.46)
PCIE_WAKE#: length 46.3
  TOP w0.089: v1(21.67,71.76) 22.1,71.32 22.93,71.32 22.96,71.29 U2401.4 24.34,71.29 26.65,68.99 27.16,68.99 27.62,68.53 30.03,68.53 30.16,68.66 v1(30.69,68.66) ; v1(51.84,73.66) 51.84,74.2 52.89,75.24 52.89,78.33 v1(51.54,79.68)
  BOTTOM w0.089: R2495.2 21.81,71.91 v1(21.67,71.76) ; v1(30.69,68.66) 31.11,68.66 32.13,69.68 32.13,71.29 33.01,72.17 34.66,72.17 35.51,73.02 37,73.02 37.41,73.43 46.79,73.43 47.19,73.83 49.16,73.83 49.37,73.63 51.22,73.63 51.26,73.66 v1(51.84,73.66) ; D2404.3 50.93,80.29 v1(51.54,79.68) v2(50.85,79.68)
PD4403_A: length 3.5
  BOTTOM w0.089: PD4404.A 212.75,45.47 212.52,45.7 v2(212.09,45.7) 211.65,45.25 PQ4408.B
PD4403_K: length 4.3
  TOP w0.089: PR4477.2 212.47,45.7 PR4452.2 212.78,46 v2(213.38,46) 213.51,46 v1(214.01,45.51)
  BOTTOM w0.089: PD4404.K 215.1,45.16 214.35,45.16 v1(214.01,45.51)
PD_SWD_CLK: length 2.1
  TOP w0.089: TP7201.1 43.34,108.94 43.12,109.16 U7201.1
PD_VBUS_C_CTRL1: length 22.3
  TOP w0.089: v1(37.82,110.53) 37.96,110.66 U7201.15 ; Q7406.5 29.82,107.82 29.01,107.01 v1(29.01,106.89)
  L6 w0.089: v1(37.82,110.53) 37.29,110 37.29,109.13 36.4,108.24 36.05,108.24 35.74,108.54 35.74,108.91 35.15,109.51 32.31,109.51 31.99,109.83 31.02,109.83 28.96,107.77 28.96,106.94 v1(29.01,106.89)
  BOTTOM w0.089: v1(29.01,106.89) 29.01,108.53 29.13,108.66 29.13,109.22 28.88,109.47 28.53,109.47 28.43,109.37 28.27,109.37 27.55,108.65 27.55,108.43 v2(27.05,107.94) 26.76,107.94 26.39,107.57 Q7405.2
PD_VBUS_C_CTRL1_A: length 2.3
  BOTTOM w0.089: Q7404.3 25.62,108.5 25.74,108.37 v2(25.74,107.94) Q7405.1
PD_VBUS_C_CTRL1_R: length 6
  BOTTOM w0.089: R7429.1 26.39,104.42 Q7405.5 ; R7429.1 25.74,104.51 Q7405.6 25.74,105.25 25.16,105.83 25.16,106.27 25.1,106.34 25.1,107.06 24.74,107.42 R7426.2 ; R7429.1 v2(26.11,103.25)
PD_VBUS_C_EN_A: length 16.9
  TOP w0.089: v1(26.52,114.99) 26.77,115.24 Q7407.5 ; v1(26.52,114.99) v2(26.29,115.62) ; v1(26.52,114.99) 26.92,114.59 Q7407.6
  BOTTOM w0.089: v1(26.52,114.99) 26.52,114.2 27,113.72 R7431.1 26.73,113.17 26.49,113.17 24.92,111.61 24.92,110.49 24.59,110.16 R7425.2 25.17,109.27 25.17,108.36 25.35,108.18 25.35,106.1 25.48,105.97 26.93,105.97 27.04,106.09 Q7405.3
PD_VBUS_C_EN_B: length 46.5
  TOP w0.089: R7433.2 v1(54.87,124.64) ; v1(41.15,121.95) 40.4,121.95 U7419.A3 ; Q7407.3 30.04,115.89 R7427.2 30.28,114.61 v2(30.41,114.48) 31.04,113.84 31.04,111.94 31.83,111.15 R7422.1 32.69,111.05 v1(32.99,110.75)
  L5 w0.089: v1(41.15,121.95) 41.05,121.95 40.28,122.72 37.78,122.72 35.97,120.91 35.08,120.91 34.3,120.12 34.3,119.24 34.52,119.02 34.52,112.43 34.5,112.41 34.5,112.19 33.07,110.75 v1(32.99,110.75)
  L6 w0.089: v1(41.15,121.95) 43.67,121.95 45.72,124 45.72,125.02 49.03,128.32 51.82,128.32 54.87,125.27 v1(54.87,124.64)
PD_VBUS_DISCHG: length 7.1
  TOP w0.089: Q7408.G 34.54,109.96 R7415.1 34.84,110.26 35.18,110.26 35.41,110.49 35.92,110.49 v2(36.22,110.8) 36.45,111.02 37.31,111.02 37.42,111.13 37.42,111.99 37.7,112.27 38.81,112.27 38.94,112.39 U7201.12
PD_VBUS_DISCHG_N1: length 57.7
  TOP w0.089: v1(45.55,129.06) 45.59,129.06 R7410.2 ; v2(34.7,106.71) 33.93,106.71 Q7408.D 33.59,107.58 v1(33.84,107.82)
  L5 w0.089: v1(33.84,107.82) 33.84,106.54 31.07,103.77 29.81,103.77 29.19,103.15 29.19,101.85 29.06,101.72 28.6,101.72 27.1,103.22 27.1,110.34 27.31,110.54 27.69,110.54 28.27,111.12 28.27,117.2 27.52,117.95 27.52,120.99 28.1,121.57 28.1,125.98 30.69,128.58 45.06,128.58 v1(45.55,129.06)
PD_VCCD: length 1.9
  TOP w0.254: C7202.1 40.88,107.47 v2(40.83,107.52) 40.83,107.52 U7201.22
PD_XRES: length 3.6
  TOP w0.089: U7201.7 42.29,112.39 42.52,112.17 v2(43.41,112.17) 43.41,112.88 C7213.1 43.23,113.26 R7211.1
PDB_R: length 2
  TOP w0.089: HDA27.40 29.64,15.57 30.04,15.96 30.25,15.96 v2(30.25,15.97) 30.29,15.97 30.38,16.05 R2712.2
PECI_CPU: length 85.3
  TOP w0.114: v1(48.77,73.41) 48.49,73.41 47.02,71.94 46.93,71.94 46.93,71.93 45.5,71.93 45.1,72.33 43.71,72.33 42.65,71.27 R2437.2
  L5 w0.114: v1(89.46,108.4) 84.73,113.13 79.93,113.13 78.7,114.36 73.46,114.36 72.75,113.65 67.02,113.65 64.95,111.58 64.6,111.58 62.87,109.86 62.87,108.23 62.63,107.99 62.63,106.34 62.25,105.95 62.25,105.79 60.11,103.64 60.11,99.09 59.52,98.5 59.52,97.81 57.34,95.63 55.63,95.63 53.95,93.95 53.95,93.13 51.06,90.24 51.06,89.1 51.64,88.52 51.64,81.08 50.96,80.4 50.96,78.65 50.68,78.36 50.68,75.95 48.77,74.04 v1(48.77,73.41)
  BOTTOM w0.114: v2(89.48,109.04) 89.46,109.02 v1(89.46,108.4) CPU1.AR1
PEQ: length 9.1
  TOP w0.089: U5802.8 v1(49.7,114.7)
  BOTTOM w0.089: R5805.2 54.51,115.15 54.51,114.02 v2(54.23,113.74) 53.62,113.13 R5816.2 52.97,112.66 50.28,112.66 49.7,113.24 v1(49.7,114.7)
PEX_PLLVDD: length 16.1
  TOP w0.508: v1(129.43,136.7) v1(130.02,137.3) 129.44,137.88 C7632.1
  L6 w0.508: v1(130.02,137.3) 129.98,137.34 129.98,139.3 131.23,140.55 131.23,141.58 130.51,142.3 130.51,146.54 132.34,148.37 132.34,148.76 v1(132.27,148.82)
  BOTTOM w0.305: GPU1.AA14 v1(129.43,136.7) ; GPU1.AA15 v1(130.02,137.3)
  vias: v2(133.12,150.17)
PEX_SVDD: length 0.7
  BOTTOM w0.381: GPU1.AB8 124.75,133.18 v1(124.71,133.14)
  vias: v2(123.58,133.7)
PEX_TERMP: length 5.3
  BOTTOM w0.089: R7601.1 128.83,147.88 v2(129.44,147.27) 130.36,146.36 131.45,146.36 132.39,145.41 GPU1.AF25
PEX_TSTCLK_OUT: length 22.7
  L6 w0.089: v1(131.24,143.08) 131.04,143.28 131.04,146.2 136.38,151.54 138.99,151.54 139.02,151.51 140.41,151.51 143.11,154.2 v1(143.11,154.51)
  BOTTOM w0.089: v1(143.11,154.51) 143.11,154.51 143.11,152.68 R7604.1 142.97,152.58 v2(141.81,152.58) ; GPU1.AF22 v1(131.24,143.08)
PEX_TSTCLK_OUT#: length 23.1
  L6 w0.089: v1(143.97,154.51) 140.8,151.33 138.94,151.33 138.92,151.36 136.57,151.36 131.35,146.13 131.35,144.09 v1(132.36,143.08)
  BOTTOM w0.089: v2(144.78,152.78) R7604.2 143.97,152.68 143.97,154.51 v1(143.97,154.51) ; GPU1.AE22 v1(132.36,143.08)
PIRQA#: length 102.3
  TOP w0.089: R9152.2 160.47,77.69 159.72,78.44 R2053.2 158.96,78.03 158.96,73.12 159.87,72.21 159.87,69.37 160.05,69.19 160.05,64.69 159.81,64.45 159.81,62.77 160.06,62.52 160.37,62.52 160.94,61.95 163.48,59.41 v2(164.49,59.41) 164.6,59.41 v1(165.13,58.88)
  L5 w0.089: v1(165.13,58.88) 164.52,58.88 162.72,57.08 128.39,57.08 120.22,65.25 120.22,66.02 108.81,77.44 108.81,83.48 106.65,85.64 106.65,86.55 v1(107.19,87.08)
  BOTTOM w0.089: CPU1.CC32 107.05,87.07 107.06,87.08 v1(107.19,87.08)
PLTRST#_CPU: length 424.4
  TOP w0.089: v1(43.17,102.87) 42.94,103.1 AFTP6108.1 ; v1(51.84,73) 51.42,73.43 51.42,74.02 52.71,75.32 52.71,77.8 51.47,79.05 50.9,79.05 50.1,79.85 50.1,81.33 48.49,82.94 U3101.19 ; v1(193.73,65) 194.33,65.6 200.24,65.6 201.48,64.37 210.89,64.37 211.42,63.84 211.42,62.32 213.06,60.68 213.06,60.51 213.06,60.51 213.06,60 215.8,57.26 215.8,57.26 215.9,57.16 215.9,55.37 216.72,54.55 WWAN1.19 ; v1(161.15,77.71) 161.15,77.72 161.74,78.31 U9103.17
  L5 w0.089: v1(43.17,102.87) 42.76,103.28 42.76,103.71 42.88,103.83 42.88,107.01 44.04,108.17 44.04,112.1 45.44,113.49 46.73,113.49 47.15,113.91 47.15,115 49.88,117.73 49.88,118.27 51.1,119.49 51.1,123.58 50.28,124.4 50.27,124.4 50.18,124.4 49.55,125.03 49.55,125.47 v1(49.94,125.86) ; v1(117.38,123.32) 118.01,123.95 119.84,123.95 123.91,119.88 123.91,119.62 126,117.53 127.4,117.53 130.18,114.74 130.18,112.85 130.41,112.63 130.41,110.78 129.44,109.81 128.5,108.87 128.5,108.61 v1(128.02,108.13) 128.58,107.57 128.58,106.15 130.05,104.67 130.05,101.14 129.56,100.65 129.56,100.47 130.08,99.95 v1(130.08,99.64) 129.56,99.12 129.56,98.94 130.91,97.59 130.91,96.59 131.06,96.44 131.06,92.79 131.36,92.49 131.36,75.6 132.37,74.59 157.83,74.59 160.95,77.71 v1(161.15,77.71) 162.02,77.71 163.52,76.21 166.09,76.21 169.6,72.7 171.91,72.7 172.16,72.96 172.16,74.68 172.75,75.26 173.53,75.26 176.66,72.13 176.66,71.05 178.39,69.32 179.29,69.32 182.32,66.29 182.32,65 184.59,62.73 188,62.73 189.47,64.19 193.17,64.19 193.73,64.75 v1(193.73,65)
  L6 w0.089: v1(23.8,27.26) 23.49,27.26 22.01,28.74 22.01,36.25 21.59,36.68 21.59,42.48 21.05,43.02 21.05,50.56 21.54,51.06 21.54,52.76 20.71,53.59 20.71,57.91 24.18,61.38 24.18,61.43 24.18,62.95 29.4,68.17 v1(30.28,68.17) 31.01,68.17 32.21,69.37 37.85,69.37 39.34,70.87 40.26,70.87 44.07,74.68 44.07,80.55 45.24,81.71 45.24,82.37 45.93,83.06 46.22,83.06 46.73,83.57 46.73,85.16 48.11,86.54 48.11,91.03 45.9,93.24 44.5,93.24 42.73,95.01 42.73,102.44 v1(43.17,102.87) ; v1(117.38,123.32) 116.81,123.88 115.08,123.88 114.61,124.35 112.51,124.35 112.21,124.05 111,124.05 109.5,125.56 96.58,125.56 96.06,125.04 87.53,125.04 85.19,122.7 65.15,122.7 64.56,123.28 64.56,123.28 64.35,123.5 58.8,123.5 58,124.31 55.73,124.31 55.48,124.05 54.38,124.05 52.23,126.21 50.07,126.21 49.94,126.09 v1(49.94,125.86)
  BOTTOM w0.089: R1715.1 158.7,80.11 158.37,79.78 R1713.1 158.74,79.33 ED1701.2 159.76,78.33 C1701.1 160.79,78.08 v1(161.15,77.71) ; v1(30.28,68.17) 30.88,68.17 32.39,69.69 32.39,70.81 32.72,71.14 33.19,71.14 33.43,71.39 33.43,71.72 33.71,71.99 34.73,71.99 35.58,72.84 37.08,72.84 37.49,73.25 47.97,73.25 48.5,72.73 49.61,72.73 50.27,73.38 51.46,73.38 v1(51.84,73) ; R2616.1 128.13,108.13 v1(128.02,108.13) ; WLAN1.52 43.7,103.41 v1(43.17,102.87) ; SSD1.50 24.2,26.45 23.8,26.85 v1(23.8,27.26) ; v1(130.08,99.64) 130.44,99.29 131.45,99.29 131.75,98.99 132.3,98.99 132.96,98.32 135,98.32 135.28,98.05 136.58,98.05 136.91,97.71 136.91,96.72 137.19,96.45 U7601.2
PM_LAN_ENABLE: length 114.3
  TOP w0.089: R2466.1 v1(18.6,71.71) ; v1(48.29,132.92) 48.25,132.88 U4001.5
  L6 w0.089: v1(24.74,71.5) 25.17,71.5 25.37,71.7 28.06,71.7 29.32,72.95 29.52,73.16 38.58,73.16 41.11,75.68 41.11,76.18 41.46,76.54 41.96,76.54 42.22,76.8 42.22,92.16 40.06,94.32 37.64,94.32 37.59,94.36 37.21,94.75 36.98,94.97 36.98,97.16 35.17,98.98 26.26,98.98 26.16,99.08 23.25,101.99 23.25,111.05 25.16,112.96 26.5,112.96 28.83,115.29 28.83,116.84 29.82,117.83 29.82,117.83 30,118.01 32.37,118.01 32.69,118.01 32.75,117.95 34.08,117.95 34.52,118.39 38.08,118.39 38.53,118.85 38.53,120.42 40.29,122.18 40.29,123.31 43.87,126.89 43.98,126.89 46.08,128.99 46.08,130.71 v1(48.29,132.92)
  BOTTOM w0.089: v1(18.6,71.71) 21.12,71.71 21.49,71.34 21.84,71.34 21.88,71.38 23.78,71.38 23.93,71.23 v2(24.02,71.23) 24.47,71.23 v1(24.74,71.5)
PM_RSMRST#: length 111.3
  TOP w0.089: Q1701.3 156.26,71.71 156,71.97 R1702.1 ; R1702.1 155.31,71.97 154.59,71.25 154.59,69.72 154.61,69.7 154.61,69.1 155.59,68.11 RN1703.4 155.45,67.24 155.45,66.85 155.81,66.49 156.57,66.49 156.99,66.07 156.99,63.77 159.59,61.17 160.71,61.17 163.07,58.81 163.07,58.25 v2(163.68,57.64) 164.29,57.03 165.16,57.03 v1(165.53,57.41) ; R1702.1 155.46,71.99 Q1702.2
  L6 w0.089: v1(101.75,88.48) 101.75,88.41 102.14,88.03 102.14,87.66 102.2,87.6 102.2,86.98 102.29,86.89 102.29,86.87 102.7,86.46 102.7,86.28 103.05,85.92 103.05,84.94 102.68,84.57 v1(102.68,82.93) 102.68,82.32 102.98,82.02 103.21,82.02 112.75,72.49 112.75,69.6 126.33,56.01 162.29,56.01 164.16,57.88 165.06,57.88 v1(165.53,57.41)
  BOTTOM w0.089: CPU1.BR36 101.96,84.33 102.68,83.61 v1(102.68,82.93) ; v1(101.75,88.48) 101.73,88.48 101.72,88.47 101.63,88.47 101.32,88.15 CPU1.BP30
PM_RSMRST#_M: length 3.4
  TOP w0.089: Q1702.5 155.46,75.29 R1737.2 155.08,75.73 155.07,75.75 v2(155.03,75.75) 154.99,75.75 154.81,75.57 Q1702.6
POWER_SW_IN#: length 7.3
  TOP w0.089: U2401.127 25.55,74.65 25.38,74.83 24.36,74.83 23.6,75.59 23.6,75.69 C2426.1 22.43,76.18 22.15,75.9 v2(21.85,75.9) 21.69,75.74 R2451.1 21.21,75.49 R2432.2
PQ3802_1: length 11.2
  TOP w0.305: v1(25.66,96.19) 26.04,96.19 v2(26.24,96.39) 26.44,96.6 R4309.2 ; Q4302.B 19.99,96.47 R4302.1 v1(19.99,93.65)
  L5 w0.635: v1(25.66,96.19) 23.96,94.49 20.83,94.49 v1(19.99,93.65)
PQ4348_D: length 14.5
  TOP w0.305: Q4448.D v1(31.4,125.43)
  TOP w0.508: v1(37.49,127.99) 37.52,127.97 R4466.2 ; R4469.1 v1(30.99,127.7)
  L5 w0.508: v1(31.4,125.43) 31.4,126.11 30.99,126.52 v1(30.99,127.7) 31.28,127.99 v1(37.49,127.99)
  BOTTOM w0.254: v2(27.92,128.42) 30.27,128.42 v1(30.99,127.7)
PQ4405_2: length 6.4
  TOP w0.089: v1(208.74,45.65) 209.07,45.97 v2(209.07,46.1) 208.96,46.2 PR4462.1 207.92,46.41 PR4463.1
  BOTTOM w0.089: v1(208.74,45.65) 208.74,44.6 208.46,44.32 PQ4405.2
PQ4405_3: length 1.3
  BOTTOM w0.089: PQ4405.3 205.94,42.69 PR4476.1
PQ4405_5: length 6.1
  TOP w0.089: v1(204.57,43.11) 204.57,41.46 205.01,41.02 PC4438.1 205.31,40.36 PR4474.2 v2(204.4,40.31)
  BOTTOM w0.089: v1(204.57,43.11) 204.65,43.11 204.96,43.42 204.96,44.02 204.65,44.32 PQ4405.5
PQ4405_6: length 5.5
  TOP w0.089: v1(203.41,44.17) 203.93,43.64 PR4450.1 205.46,42.98 v2(205.24,42.75) 205.24,42.01 PC4438.2
  BOTTOM w0.089: v1(203.41,44.17) 203.41,44.53 203.85,44.97 PQ4405.6
PQ4408_C: length 4.4
  TOP w0.089: 207.27,46.2 207.27,45.96 PR4475.1 208.29,44.93 v2(208.66,44.93) 208.71,44.93 209.22,45.44 v1(209.35,45.44)
  BOTTOM w0.089: v1(209.35,45.44) 209.64,45.73 PQ4408.C
PQ4408_E: length 3.4
  TOP w0.089: PR4473.2 209.96,44.22 v1(210.57,44.22) 210.57,44.67 v2(210.72,44.82) 210.82,44.92 PR4436.1
  BOTTOM w0.089: PQ4408.E 210.36,44.22 v1(210.57,44.22)
PQ4417_D: length 5.4
  TOP w0.089: PQ4417.D 11.84,128.32 PR4498.2 13.54,128.32 14.25,129.03 v2(15.09,129.03) 15.47,129.03 15.7,128.8 PR4431.2
PQ4417_G: length 2.9
  TOP w0.089: v2(11.23,130.43) 11.81,129.85 PQ4417.G 12.72,129.31 PR4430.1
PQ4418_2: length 3.4
  TOP w0.089: PR4499.1 13.34,126.75 PR4498.1 12.96,127.46 12.72,127.7 v2(12.42,127.7) 11.76,127.04 PQ4418.2
PQ4418_3: length 5.2
  TOP w0.089: PR4433.1 13.01,124.77 12.8,124.97 12.8,125.58 12.62,125.76 11.31,125.76 11.11,125.95 ; PQ4418.3 11.11,125.95 ; 11.11,125.95 10.46,125.3 v2(10.01,125.3)
PQ4418_5: length 4.4
  TOP w0.089: v2(11.43,123.62) v1(12.07,123.62) 12.07,124 11.76,124.31 PQ4418.5
  BOTTOM w0.089: PC4449.1 PR4497.2 12.4,123.95 v1(12.07,123.62)
