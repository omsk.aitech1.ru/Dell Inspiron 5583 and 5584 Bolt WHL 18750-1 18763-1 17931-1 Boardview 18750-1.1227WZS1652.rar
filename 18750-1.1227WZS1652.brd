# Allegro board 18750-1.1227WZS1652.brd (continued)
## Nets (continued)
PWR_VGA_NVVDD_BOOT2_A: PC8575.1 PR8574.2
PWR_VGA_NVVDD_EN: PR8526.1 Q8705.2 U8804.4
PWR_VGA_NVVDD_EN_R: PR8526.2 PU8514.3
PWR_VGA_NVVDD_HG1: PU8510.1 PU8512.1 PU8514.2
PWR_VGA_NVVDD_HG2: PU8514.14 PU8515.1 PU8516.1
PWR_VGA_NVVDD_LGATE1: PR8508.1 PU8510.8 PU8512.8 PU8514.19
PWR_VGA_NVVDD_LGATE2: PU8514.17 PU8515.8 PU8516.8
PWR_VGA_NVVDD_PG: PR8530.2 PU8514.13 U7302.1
PWR_VGA_NVVDD_PHASE1: PC8572.2 PL8508.1 PR8501.1 PU8510.9 PU8512.9 PU8514.20
PWR_VGA_NVVDD_PHASE2: PC8575.2 PL8509.1 PR8502.1 PU8514.16 PU8515.9 PU8516.9
PWR_VGA_NVVDD_PVCC: PC8550.1 PR8551.2 PU8514.18
PWR_VGA_NVVDD_REFADJ: PR8558.2 PU8514.6
PWR_VGA_NVVDD_REFADJ_R: PC8555.1 PR8556.2 PR8557.2 PR8558.1
PWR_VGA_NVVDD_REFIN: PC8554.1 PR8557.1 PR8559.2 PU8514.7
PWR_VGA_NVVDD_REFIN_R: PR8559.1 PR8560.2
PWR_VGA_NVVDD_TON: PR8553.2 PU8514.9
PWR_VGA_NVVDD_TON_1: PC8551.2 PR8552.2 PR8553.1
PWR_VGA_NVVDD_VREF: PC8553.2 PR8556.1 PU8514.8
PWR_VGA_NVVDD_VSEN: PC8558.1 PC8559.1 PR8503.2 PR8504.2 PR8517.1 PR8576.1
PWR_VGA_NVVDD_VSEN_N: PC8553.1 PC8554.2 PC8555.2 PC8558.2 PC8560.1 PR8505.1 PR8520.1 PR8560.1 PU8514.10
PWR_VGA_NVVDD_VSEN_P: PR8503.1 PR8512.2 PU8514.12
PWR_VGA_NVVDD_VSNS/SS: PR8513.2 PR8576.2 PU8514.11
PWR_VGA_SNUB1: PC8507.1 PR8501.2
PWR_VGA_SNUB2: PC8508.1 PR8502.2
PWRNC1*: VRAM1.A10
PWRNC2*: VRAM1.U10
PWRNC3*: VRAM4.A10
PWRNC4*: VRAM4.U10
Q501_G: Q501.D Q502.G R506.2
Q5503_B: Q5502.B R5554.2
Q5503_C: Q5502.C R5546.1
Q5503_E: Q5502.E R5551.1
Q5504_B: Q5501.B R5553.2
Q5504_C: Q5501.C R5548.1
Q5505_E: Q5501.E R5550.1
Q6205_Q: Q6503.D R6503.2
Q6407_B: Q6407.1 Q6408.C R6405.1
Q6407_C: Q6407.3 R6413.2
REGOUT: C3118.1 R3101.1 U3101.24
RESET_OUT#: C2614.1 CPU1.BP31 ED1705.2 Q2602.G R2616.2 RN1703.3(B) U2401.73
REXT1: R5804.1 U5802.20
RING2_HPMIC1: ED2911.2 HPMIC1.3 R2906.2
RSET: R3102.1 U3101.31
RSMRST_PWRGD#: D4002.K R4029.2 R4030.2 R4031.2 R4033.2
RTC_3P3_EN_G: Q2510.D R2506.1
RTC_DET#: CPU1.CP22 Q2505.D R1554.2
RTC_RST#: C1806.1 CPU1.BR34 ED1802.2 G1801.2 RN1801.4(B)
RTCRST_ON: D2502.K Q2507.G R2518.1 R2567.1 U2401.31
RUNPWROK: D4002.A D4003.A ED1706.2 R1716.1 R4002.1 R4005.2 R4011.2 U2401.48
SA0_CHA_DIM0: DM1.256 R1204.1 R1205.1
SA0_CHB_DIM0: DM2.256 R1302.1 R1303.1
SA1_CHA_DIM0: DM1.260 R1208.1 R1210.1
SA1_CHB_DIM0: DM2.260 R1306.1 R1307.1
SA2_CHA_DIM0: DM1.166 R1211.1 R1212.1
SA2_CHB_DIM0: DM2.166 R1310.1 R1311.1
SATA1_ODD_PRSNT#: CPU1.CM10 R1617.2 R6004.1
SATA_LED#: CPU1.CN7 D6401.1 R1606.2
SATA_LED#_D: D6401.3 Q6401.S R6415.2
SATA_ODD_DA#_C: ODD1.16 TP6001.1
SATA_ODD_PRSNT#_R: AFTP6005.1 ODD1.7 R6004.2
SD_RCOMP: CPU1.CK33 CPU1.CM34 R1901.1
SD_READ_MODE#: AFTP6610.1 CPU1.CA30 R6601.1
SD_READ_MODE#_R: IOBD1.3 R6601.2
SIO_EXT_SMI#: CPU1.CP7 R407.1
SIO_EXT_WAKE#: CPU1.CN12 R2041.2 U2401.116
SIO_PWRBTN#: CPU1.BU28 TP1706.1 U2401.52
SIO_RCIN#: CPU1.BV29 R1820.2
SIO_SLP_A#: CPU1.BU37 TP1705.1
SIO_SLP_S0#: CPU1.BJ37 R1739.1 R4040.1 R9121.2
SIO_SLP_S3#: C1703.1 CPU1.BU36 D4003.K R4017.1 U4001.3 U4004.3 U4004.5 U4007.1
SIO_SLP_S4#: C1702.1 CPU1.BU27 PR5117.2 Q9202.G R4024.1
SIO_SLP_S5#: CPU1.BT29 TP1702.1
SKTOCC#: CPU1.E1 TP619.1
SLEEVE_R: ED2912.1 HPMIC1.4 R2911.2
SM_DRAMRST#_CPU: CPU1.BU31 R504.1 R505.2
SM_INTRUDER#: CPU1.BR35 R1730.2
SM_PGCNTL: CPU1.C35 Q501.G
SM_PGCNTL_Q: PU5102.5 Q502.D R507.2
SM_RCOMP_0: CPU1.BN28 R501.1
SM_RCOMP_1: CPU1.BN27 R502.1
SM_RCOMP_2: CPU1.BN29 R503.1
SMB_ALERT#: CPU1.CJ15 R1551.2
SMBC_THERM_NV: GPU1.D9 Q7901.4 RN7901.2(A)
SMBD_THERM_NV: GPU1.D8 Q7901.1 RN7901.1(A)
SML0_ALERT#: CPU1.CG15 R1504.2 R1806.1
SML0_SMBCLK: CPU1.CH14 RN1807.6(B)
SML0_SMBDATA: CPU1.CF15 RN1807.7(B)
SML1_SMBCLK: CPU1.CN15 Q2601.3 Q7901.3 R2459.1 RN1811.3(B)
SML1_SMBDATA: CPU1.CM15 Q2601.6 Q7901.6 R2447.1 RN1811.4(B)
SML1ALERT#: CPU1.CC34 R1837.2
SPI_CLK_CPU: R1842.1 R2508.2 R2513.2 R9138.1
SPI_CLK_CPU_R: CPU1.CH37 R1842.2
SPI_CLK_ROM: BIOS1.6 EC2503.1 R2508.1
SPI_CLK_ROM2: BIOS2.6 EC2504.1 R2513.1
SPI_CLK_ROM_TPM: R9138.2 U9103.19
SPI_CS2#_IC: R9130.2 R9148.2 U9103.20
SPI_CS_CPU_N0: BIOS1.1 CPU1.CG36 R2519.2
SPI_CS_CPU_N1: BIOS2.1 CPU1.CG35 R2521.2
SPI_CS_CPU_N2: CPU1.CH34 R9118.2 R9130.1
SPI_HOLD_CPU: R1510.2 R1846.1 R2503.2 R2511.2
SPI_HOLD_CPU_R: CPU1.CG34 R1846.2
SPI_HOLD_ROM: BIOS1.7 R2503.1
SPI_HOLD_ROM2: BIOS2.7 R2511.1
SPI_IRQ#_TPM2: R9119.1 R9151.1 R9152.1 U9103.18
SPI_SI_CPU: R1506.2 R1844.1 R2509.2 R2512.2 R9133.1
SPI_SI_CPU_R: CPU1.CF36 R1844.2
SPI_SI_ROM: BIOS1.5 EC2501.1 R2509.1
SPI_SI_ROM2: BIOS2.5 EC2505.1 R2512.1
SPI_SI_ROM_TPM: R9133.2 U9103.21
SPI_SO_CPU: R1843.1 R2501.1 R2502.1 R9132.1
SPI_SO_CPU_R: CPU1.CF37 R1843.2
SPI_SO_ROM: BIOS1.2 EC2502.1 R2502.2
SPI_SO_ROM2: BIOS2.2 EC2506.1 R2501.2
SPI_SO_ROM_TPM: R9132.2 U9103.24
SPI_WP_CPU: R1508.2 R1845.1 R2507.1 R2510.1
SPI_WP_CPU_R: CPU1.CF34 R1845.2
SPI_WP_ROM: BIOS1.3 R2507.2
SPI_WP_ROM2: BIOS2.3 R2510.2
SPKR: CPU1.CF35 R2740.1
SRTC_RST#: C1805.1 CPU1.BR37 ED1801.2 RN1801.3(B)
SSD2_DEVSLP: CPU1.CR8 R1619.1
SSD_CLK_CPU_N_4: CPU1.BA1 SSD1.53
SSD_CLK_CPU_P_4: CPU1.BA2 SSD1.55
SSD_DEVSLP: CPU1.CM8 R1618.1
SSD_DEVSLP_R: R1618.2 R1619.2 R6301.1
SSD_PCIE_RX_N13: CPU1.BK6 SSD1.5
SSD_PCIE_RX_N14: CPU1.BJ6 SSD1.17
SSD_PCIE_RX_N15: CPU1.BG5 SSD1.29
SSD_PCIE_RX_N16: CPU1.BE5 SSD1.43
SSD_PCIE_RX_P13: CPU1.BK5 SSD1.7
SSD_PCIE_RX_P14: CPU1.BJ5 SSD1.19
SSD_PCIE_RX_P15: CPU1.BG6 SSD1.31
SSD_PCIE_RX_P16: CPU1.BE6 SSD1.41
SSD_PCIE_TX_CON_N13: C6316.1 SSD1.11
SSD_PCIE_TX_CON_N14: C6314.1 SSD1.23
SSD_PCIE_TX_CON_N15: C6312.1 SSD1.35
SSD_PCIE_TX_CON_P13: C6315.1 SSD1.13
SSD_PCIE_TX_CON_P14: C6313.1 SSD1.25
SSD_PCIE_TX_CON_P15: C6311.1 SSD1.37
SSD_PCIE_TX_N13: C6316.2 CPU1.BM4
SSD_PCIE_TX_N14: C6314.2 CPU1.BL2
SSD_PCIE_TX_N15: C6312.2 CPU1.BL4
SSD_PCIE_TX_N16: C6303.2 CPU1.BJ4
SSD_PCIE_TX_P13: C6315.2 CPU1.BM3
SSD_PCIE_TX_P14: C6313.2 CPU1.BL1
SSD_PCIE_TX_P15: C6311.2 CPU1.BL3
SSD_PCIE_TX_P16: C6302.2 CPU1.BJ3
SSD_SATA_TX_CON_N16: C6303.1 SSD1.47
SSD_SATA_TX_CON_P16: C6302.1 SSD1.49
SSD_SCP#: SSD1.8 U2401.21
SSEQ0_A0: R7145.2 R7146.1 U7101.11
SSEQ1: R7144.1 R7152.2 U7101.3
ST_GPIO: TP9103.1 U9103.6
ST_PP: TP9101.1 U9103.7
STRAP0: GPU1.D1 R7908.1 R7919.2
STRAP1: GPU1.D2 R7909.2 R7911.1
STRAP2: GPU1.E4 R7914.2 R7915.1
STRAP3: GPU1.E3 R7926.1 R7977.2
STRAP4: GPU1.D3 R7929.1 R7976.2
STRAP5: GPU1.C1 R7945.2
STRAP5_R: R7939.1 R7945.1 R7978.2
STRAP_REF0_GND_N9: GPU1.F6 R7907.2
SUS_CLK: CPU1.BT32 EC1803.2 R2461.1 R6117.1
SUSACK#_R: CPU1.BY32 R1708.2
SUSCLK_WLAN: R6117.2 WLAN1.50
SVID_ALERT#_CPU: PR4605.2 PR4623.1 R703.1 R704.2
SVID_ALERT#_CPU_R: CPU1.AA3 R703.2
SVID_ALERT#_VR: PR4623.2 PU4601.36
SVID_CLK_CPU: PR4606.2 PR4624.1 R702.2 R705.2
SVID_CLK_CPU_R: CPU1.AA1 R702.1
SVID_CLK_VR: PR4624.2 PU4601.37
SVID_DATA_CPU: PR4604.2 PR4622.1 R701.2 R706.2
SVID_DATA_CPU_R: CPU1.AA2 R701.1
SVID_DATA_VR: PR4622.2 PU4601.35
SW_PIN: R5820.2 U5802.18
SYS_LED_MASK#: Q3201.G Q6402.G Q6406.2 Q6406.5 R2465.1 R2497.1 U2401.55
SYS_PEX_RST_MON#: R7606.1 R7613.1 R7922.2 R7974.2 U7601.4 U7602.2
SYS_PEX_RST_MON_GPU#: GPU1.E9 R7974.1
SYS_PRES1#: AFTP4315.1 BATT1.7 R4301.2
SYS_PWROK: CPU1.CR10 ED1702.2 R1717.1 U2401.28
SYSPWR_PRES: R2454.1 R2463.2 U2401.120
T_CRIT#: R2601.1 R2604.2 U2601.4
TESTMODE: GPU1.AD9 R7602.1
THERM_SYS_SHDN#: Q2602.S R2601.2 R2602.1
THERMTRIP#_CPU: CPU1.BJ1 ED301.1 R308.2
TOP_MUX_N: ED7311.2 EL7105.3 JUSB1.A7 R7333.2
TOP_MUX_N_L: EL7105.4 R7131.2 U7102.17
TOP_MUX_P: ED7312.2 EL7105.2 JUSB1.A6 R7332.2
TOP_MUX_P_L: EL7105.1 R7132.2 U7102.18
TOUCH_I2C_DET#: AFTP5501.1 CPU1.CC29 LCD1.12 R2062.2
TOUCH_PAD_INTR#: CPU1.CB34 R319.2
TOUCH_PANEL_INTR#: CPU1.CN3 R5533.1 R5544.2
TOUCH_PANEL_PD#: AFTP5503.1 CPU1.CC35 LCD1.14
TOUCH_REPORT_SW: AFTP5514.1 D2402.A LCD1.26
TOUCH_USB20_N: CPU1.CH5 R5511.1
TOUCH_USB20_N_R: ED5502.4 LCD1.28 R5511.2
TOUCH_USB20_P: CPU1.CH6 R5512.1
TOUCH_USB20_P_R: ED5502.3 LCD1.27 R5512.2
TP_EN#: R2499.2 R6504.1 U2401.49
TP_ON#_GATE: C6502.2 Q6502.G Q6503.G R6504.2
TP_VDD: AFTP6529.1 C6505.1 Q6502.D R6502.2 R6503.1 R6511.2 RN6501.1(A) RN6501.2(A) RN6503.1(A) RN6503.2(A) TP1.8
TP_WAKE_KBC#: AFTP6525.1 R319.1 R6511.1 TP1.4 U2401.33
TPAN_VDD_EN_R: R5559.2 R5560.2 R5564.1 U5503.5
TPCLK_C: AFTP6530.1 RN6502.4(B) TP1.1
TPDATA_C: AFTP6524.1 RN6502.3(B) TP1.2
TPM_GPIO0: R9121.1 U9103.29
TPM_GPIO1: TP9102.1 U9103.30
TPM_GPIO4: R9118.1 U9103.13
TPM_ID: CPU1.CK25 R1910.2 R1911.1
TPM_SPI_IRQ#: CPU1.CF20 R9151.2
TPS2544_FAULT#: R3607.1 U3601.13
TPS70933_EN: Q7201.D R7217.2 R7218.1 U7203.4
TPS70933_EN_G: C7215.2 Q7201.G R7216.2
TS#_DIMM0_1: DM1.134 R1215.2
TS#_DIMM1_1: DM2.134 R1312.2
TS_INT#: AFTP5502.1 LCD1.13 R5533.2
TS_VREF: GPU1.AE2 TP7701.1
TYPEC_DCIN1_EN#: Q7406.2 Q7407.2 R2491.1 R7428.1 U2401.63
TYPEC_DP_AUXN: R7104.1 U5802.27
TYPEC_DP_AUXP: R7103.1 U5802.26
TYPEC_DP_N0: C7113.1 U5802.49
TYPEC_DP_N0_C: C7113.2 R7178.1
TYPEC_DP_N1: C7107.1 U5802.46
TYPEC_DP_N1_C: C7107.2 R7180.1
TYPEC_DP_N2: C7108.1 U5802.44
TYPEC_DP_N2_C: C7108.2 R7182.1
TYPEC_DP_N3: C7110.1 U5802.41
TYPEC_DP_N3_C: C7110.2 R7184.1
TYPEC_DP_P0: C7112.1 U5802.50
TYPEC_DP_P0_C: C7112.2 R7177.1
TYPEC_DP_P1: C7114.1 U5802.47
TYPEC_DP_P1_C: C7114.2 R7179.1
TYPEC_DP_P2: C7109.1 U5802.45
TYPEC_DP_P2_C: C7109.2 R7181.1
TYPEC_DP_P3: C7111.1 U5802.42
TYPEC_DP_P3_C: C7111.2 R7183.1
TYPEC_SMBCLK: Q2417.1 RN2413.4(B) U2401.91 U7102.3
TYPEC_SMBDA: Q2417.4 RN2413.3(B) U2401.89 U7102.4
U9101_2_GND: R9101.2 U9103.2
UART_2_CRXD_DTXD: CPU1.CR12 R2048.2 R6803.1
UART_2_CRXD_DTXD_CON: DBG1.14 R6803.2
UART_2_CTXD_DRXD: CPU1.CP12 R2049.2 R6802.1
UART_2_CTXD_DRXD_CON: DBG1.13 R6802.2
USB1_SBU1: AFTP7101.1 ED7307.2 JUSB1.A8 R7331.2 U7101.27
USB1_SBU2: AFTP7102.1 ED7307.1 JUSB1.B8 R7330.2 U7101.26
USB1_SSRX_CMC_N1: C7169.1 U7101.31
USB1_SSRX_CMC_N1_C: C7169.2 R7120.1 R7187.1
USB1_SSRX_CMC_N2: C7167.1 U7101.39
USB1_SSRX_CMC_N2_C: C7167.2 R7123.1 R7185.1
USB1_SSRX_CMC_P1: C7168.1 U7101.30
USB1_SSRX_CMC_P1_C: C7168.2 R7119.1 R7186.1
USB1_SSRX_CMC_P2: C7170.1 U7101.40
USB1_SSRX_CMC_P2_C: C7170.2 R7122.1 R7188.1
USB1_SSRX_CON_N1: ED7301.4 ED7301.7 JUSB1.B10 R7120.2
USB1_SSRX_CON_N2: ED7302.2 ED7302.9 JUSB1.A10 R7123.2
USB1_SSRX_CON_P1: ED7301.5 ED7301.6 JUSB1.B11 R7119.2
USB1_SSRX_CON_P2: ED7302.1 ED7302.10 JUSB1.A11 R7122.2
USB1_SSTX_C_N1: C7163.2 U7101.34
USB1_SSTX_C_N2: C7162.2 U7101.36
USB1_SSTX_C_P1: C7164.2 U7101.33
USB1_SSTX_C_P2: C7161.2 U7101.37
USB1_SSTX_CMC_N1: C7163.1 R7117.1
USB1_SSTX_CMC_N2: C7162.1 R7125.1
USB1_SSTX_CMC_P1: C7164.1 R7115.1
USB1_SSTX_CMC_P2: C7161.1 R7124.1
USB1_SSTX_CON_N1: ED7301.1 ED7301.10 JUSB1.A3 R7117.2
USB1_SSTX_CON_N2: ED7302.5 ED7302.6 JUSB1.B3 R7125.2
USB1_SSTX_CON_P1: ED7301.2 ED7301.9 JUSB1.A2 R7115.2
USB1_SSTX_CON_P2: ED7302.4 ED7302.7 JUSB1.B2 R7124.2
USB1_USB20_N: CPU1.CD3 R7134.1 U7102.2
USB1_USB20_N_R: R7131.1 R7134.2
USB1_USB20_P: CPU1.CD4 R7133.1 U7102.1
USB1_USB20_P_R: R7132.1 R7133.2
USB2_ID: CPU1.CE8 RN1602.1(A)
USB2_USB20_N: CPU1.CE1 EL6602.4 R6606.1
USB2_USB20_N_CMC: ED6601.3 EL6602.3 IOBD1.8 R6606.2
USB2_USB20_P: CPU1.CE2 EL6602.1 R6607.1
USB2_USB20_P_CMC: ED6601.4 EL6602.2 IOBD1.9 R6607.2
USB2_VBUSSENSE: CPU1.CC6 RN1602.2(A)
USB3_CHAR_2544_N: R3615.1 U3601.11
USB3_CHAR_2544_P: R3614.1 U3601.10
USB3_CHAR_N: EL3501.4 R3615.2 R3617.2
USB3_CHAR_P: EL3501.1 R3614.2 R3616.2
USB3_NONPS_N: R3611.2 R3617.1
USB3_NONPS_P: R3610.2 R3616.1
USB3_USB20_2544_N: R3613.1 U3601.2
USB3_USB20_2544_P: R3612.1 U3601.3
USB3_USB20_CON_N: AFTP3502.1 ED3502.1 EL3501.3 USB1.2
USB3_USB20_CON_P: AFTP3503.1 ED3502.6 EL3501.2 USB1.3
USB3_USB20_N: CPU1.CE3 R3611.1 R3613.2
USB3_USB20_P: CPU1.CE4 R3610.1 R3612.2
USB3_USB30_RX_CON_N: ED3501.1 ED3501.10 EL3503.3 R3508.1 USB1.5
USB3_USB30_RX_CON_P: ED3501.2 ED3501.9 EL3503.4 R3502.1 USB1.6
USB3_USB30_TX_CMC_N: C3521.2 EL3502.1 R3507.2
USB3_USB30_TX_CMC_P: C3520.2 EL3502.2 R3501.2
USB3_USB30_TX_CON_N: ED3501.4 ED3501.7 EL3502.3 R3507.1 USB1.8
USB3_USB30_TX_CON_P: ED3501.5 ED3501.6 EL3502.4 R3501.1 USB1.9
USB3_USB31_RX_N: CPU1.CB5 EL3503.1 R3508.2
USB3_USB31_RX_P: CPU1.CB6 EL3503.2 R3502.2
USB3_USB31_TX_N: C3521.1 CPU1.CA4
USB3_USB31_TX_P: C3520.1 CPU1.CA3
USB4_USB20_CON_N: ED3502.3 EL3506.2 USB2.2
USB4_USB20_CON_P: ED3502.4 EL3506.3 USB2.3
USB4_USB20_N: CPU1.CG3 EL3506.1
USB4_USB20_P: CPU1.CG4 EL3506.4
USB4_USB30_RX_C_N: C7106.2 R7155.1
USB4_USB30_RX_C_P: C7105.2 R7156.1
USB4_USB30_RX_C_R_N: R7155.2 U7101.4
USB4_USB30_RX_C_R_P: R7156.2 U7101.5
USB4_USB30_RX_CON_N: ED3503.1 ED3503.10 EL3505.3 R3505.1 USB2.5
USB4_USB30_RX_CON_P: ED3503.2 ED3503.9 EL3505.4 R3504.1 USB2.6
USB4_USB30_RX_N: C7106.1 CPU1.BW6
USB4_USB30_RX_P: C7105.1 CPU1.BW5
USB4_USB30_TX_C_N: C7104.2 R7153.1
USB4_USB30_TX_C_P: C7103.2 R7154.1
USB4_USB30_TX_C_R_N: R7153.2 U7101.7
USB4_USB30_TX_C_R_P: R7154.2 U7101.8
USB4_USB30_TX_CMC_N: C3523.2 EL3504.1 R3506.2
USB4_USB30_TX_CMC_P: C3522.2 EL3504.2 R3503.2
USB4_USB30_TX_CON_N: ED3503.4 ED3503.7 EL3504.3 R3506.1 USB2.8
USB4_USB30_TX_CON_P: ED3503.5 ED3503.6 EL3504.4 R3503.1 USB2.9
USB4_USB30_TX_N: C7104.1 CPU1.BW2
USB4_USB30_TX_P: C7103.1 CPU1.BW1
USB4_USB31_RX_N: CPU1.BY7 EL3505.1 R3505.2
USB4_USB31_RX_P: CPU1.BY6 EL3505.2 R3504.2
USB4_USB31_TX_N: C3523.1 CPU1.BY4
USB4_USB31_TX_P: C3522.1 CPU1.BY3
USB30_PS_VCC: AFTP3507.1 C3524.1 C3525.1 C3526.1 C3527.1 EC3513.1 ED3502.5 FC8910.1 R3618.2 U3601.12 USB1.1
USB_ADT: PD4407.A PD4408.2 PD4409.A R7404.1 U7418.5 U7418.6 U7418.7 U7418.8 U7419.A1 U7419.B1 U7419.C1 U7419.D1
USB_EN#: AFTP6614.1 IOBD1.12 R2434.2 U2401.13 U3502.4
USB_OC0#: CPU1.CK6 R3512.1 R3607.2 RN1601.7(B)
USB_OC1#: AFTP6613.1 CPU1.CK5 IOBD1.11 RN1601.5(B)
USB_OC1#_R: R3512.2 U3502.3
USB_OC2#: CPU1.CK8 RN1601.8(B)
USB_OC3#: CPU1.CK9 RN1601.6(B)
USB_POWERSHARE_VBUS_EN: U2401.71 U3601.5
USB_PWR_SHR_EN_L#: R2492.2 R3601.1 U2401.118
USBC1_CC1_CONN: AFTP7303.1 C7208.1 ED7315.2 JUSB1.A5 U7201.6
USBC1_CC2_CONN: AFTP7304.1 C7209.1 ED7315.1 JUSB1.B5 U7201.4
USBCOMP: CPU1.CC5 R1603.1
V_SM_VREF_CNTA: C1222.1 CPU1.F36 R1206.2
V_SM_VREF_CNTB: C1323.1 CPU1.E36 R1305.2
VCI_IN1#: R2496.1 U2401.126
VCP_VBUS: D7401.A U7403.B1 U7403.B2 U7403.C1
VCREF0: C2409.1 R2424.1 R2448.1 U2401.25
VGA_CORE_DISCHG: Q8703.3 Q8705.3 R8702.2 R8706.2
VGA_CORE_PSI: PR8522.1 R7913.2 R7966.2
VGA_CORE_VID: PR8510.1 R7960.2 R7961.2
VGA_CORE_VID_R: GPU1.C6 R7959.1 R7960.1
VGA_CT_1: C8608.1 U8601.12
VGA_DB_DET#: AFTP5601.1 CPU1.CR24 R2059.2 R5601.2
VGA_DB_DET#_R: R5601.1 VGABD1.19
VGA_NVVDD: Q8703.5 Q8703.6 R8701.1
VGA_PWR_EN#: Q8701.5 Q8701.6 R8703.1
VGACORE_GND_SENSE_1: GPU1.F1 PR8520.2
VGACORE_VDD_SENSE_1: GPU1.F2 PR8517.2
VID_PLLVDD: GPU1.N6 R7943.2
VID_PLLVDD_L: C7902.1 C7934.1 C7935.1 GPU1.M6 L7902.2 R7943.1
VIDEO_CLK_XTAL_SS: GPU1.A10 R7901.1
VR_CAP: C2418.1 U2401.18
VR_EN: PU4601.40 R4002.2
VR_RDY: PR4609.2 PU4601.39 TP4601.1
VRALERT#: CPU1.CC36 TP1708.1
VRAM_ID1: CPU1.CE27 R2007.1 R2008.2
VRAM_ID2: CPU1.CN23 R2063.1 R2064.2
VREF_CPU: C2406.1 R2402.2 U2401.95
VREG3PD: C7216.1 C7217.1 D7201.A U7203.1
WHITE_LED_BAT: EC6404.1 Q6404.C R6406.1
WIFI_RF_EN: AFTP6110.1 CPU1.CG25 R6109.2
WIFI_RF_EN_R: R6109.1 R6114.2 WLAN1.56
WLAN_CLK_CPU_N: CPU1.BC1 WLAN1.49
WLAN_CLK_CPU_P: CPU1.BC2 WLAN1.47
WLAN_EN#: Q6102.D R6102.2 U6101.4
WLAN_PCIE_RX_N10: CPU1.BN6 WLAN1.43
WLAN_PCIE_RX_P10: CPU1.BN5 WLAN1.41
WLAN_PCIE_TX_CON_N: C6107.1 WLAN1.37
WLAN_PCIE_TX_CON_P: C6108.1 WLAN1.35
WLAN_PCIE_TX_N10: C6107.2 CPU1.BR4
WLAN_PCIE_TX_P10: C6108.2 CPU1.BR3
WWAN_BB_RST#: CPU1.CF17 WWAN1.16
WWAN_CLKREQ_CPU_N: CPU1.CF31 R1825.2 WWAN1.20
WWAN_DB_DET#: CPU1.CH36 R2119.2 R2403.2 R6201.1
WWAN_DB_DET#_R: R6201.2 WWAN1.17
WWAN_FULL_PWR_EN: CPU1.CM23 R2051.1
WWAN_FULL_PWR_EN_D8: CPU1.CJ22 R2067.1
WWAN_FULL_PWR_EN_R: R2051.2 R2067.2 WWAN1.8
WWAN_GPIO_PERST#: CPU1.CH22 WWAN1.15
WWAN_PCIE_CLK_N: CPU1.BE1 WWAN1.26
WWAN_PCIE_CLK_P: CPU1.BE2 WWAN1.27
WWAN_PCIE_RX_N: CPU1.BY8 WWAN1.29
WWAN_PCIE_RX_P: CPU1.BY9 WWAN1.30
WWAN_PCIE_TX_N: C6201.1 CPU1.CA2
WWAN_PCIE_TX_N_C: C6201.2 WWAN1.32
WWAN_PCIE_TX_P: C6202.1 CPU1.CA1
WWAN_PCIE_TX_P_C: C6202.2 WWAN1.33
WWAN_PCIE_WAKE_N: TP6201.1 WWAN1.21
WWAN_USB20_N: CPU1.CB8 R6203.1
WWAN_USB20_N_R: R6203.2 WWAN1.23
WWAN_USB20_P: CPU1.CB9 R6202.1
WWAN_USB20_P_R: R6202.2 WWAN1.24
XCLK_BIASREF: CPU1.CJ1 R1803.1
XDP_CLK_CPU_N: CPU1.AU1 TP1808.1
XDP_CLK_CPU_P: CPU1.AU2 TP1807.1
XDP_DBRESET#: CPU1.CN10 R1701.2
XDP_PRDY#: CPU1.W1 TP9107.1
XDP_PREQ#: CPU1.W2 TP9106.1
XDP_TCK_JTAGX: CPU1.P6 R315.1
XDP_TCLK: CPU1.T6 R317.1
XDP_TDI: CPU1.U6 R311.1
XDP_TDO_CPU: CPU1.Y5 R310.1
XDP_TMS: CPU1.T5 R309.1
XDP_TRST#: CPU1.AB6 CPU1.Y6 R316.1
XTL_24M_X1_CPU: CPU1.CK3 R1839.1
XTL_24M_X1_R: C1807.2 R1839.2 R1841.1 X1801.1
XTL_24M_X2_CPU: CPU1.CK2 R1840.1
XTL_24M_X2_R: C1808.2 R1840.2 R1841.2 X1801.3
XTL_32K_X1_CPU: C1804.1 CPU1.BN31 R1815.1 X1802.1
XTL_32K_X2_CPU: C1803.1 CPU1.BN32 R1815.2 X1802.2
XVDD_R1: GPU1.V5 R8001.2
XVDD_R2: GPU1.V6 R8002.2
N92950396: C2517.1 D2502.A Q2510.G R2567.2

Pads without a net: CPU1 A34 A35 AA24 AA26 AB25 AC6 AC7 AC24 AC25 AC26 AD24 AD26 AG6 AG7 AH26 AJ1 AJ2 AJ3 AJ4 AJ27 AL1 AL2 AL3 AL4 AM3 AM4 AM7 AN1 AN2 AN3 AN4 AR3 AT3 AU3 AY9 B35 BB9 BB24 BC24 BC28 BH3 BH4 BJ34 BJ36 BK34 BK35 BK36 BL34 BL36 BL37 BP8 BP9 BP28 BP29 BP34 BP35 BR18 BT8 BT9 BT31 BU29 BV24 BV25 BV30 BW34 BW35 BW36 BW37 BY30 BY31 C34 CA32 CA34 CA35 CA36 CA37 CF12 CF22 CF27 CF29 CG1 CG2 CG14 CG23 CH7 CH8 CH9 CH20 CH25 CH27 CH28 CH30 CH32 CJ27 CJ29 CJ30 CJ31 CK17 CK22 CK23 CM16 CM18 CM19 CM20 CM27 CM28 CM35 CN8 CN16 CN18 CN19 CN22 CN26 CN28 CN35 CN36 CP3 CP4 CP6 CP16 CP18 CP26 CP28 CR3 CR4 CR16 CR18 CR20 CR28 CR35 D34 D35 D37 F34 F37 G1 G2 G3 G4 H3 H4 J1 J2 J3 K12 K14 K15 K17 K18 K20 L1 L2 L3 L4 L5 L25 M3 M4 M24 M26 N1 N2 N3 N4 N5 P24 P26 R1 R2 R4 R24 R25 R26 T3 T4 T25 U34 U35 V24 V25 V28 V29 W3 W25 Y3 Y24 Y25; DBG1 1 12; DCIN1 5; DM1 87 88 91 92 95 97 100 101 104 105 162 165; DM2 87 88 91 92 95 97 100 101 104 105 162 165; ED2403 1; ED5703 4 7; ED9202 3 4; GPU1 A16 A22 AA1 AA2 AA3 AA4 AA5 AA6 AB1 AB2 AB3 AB4 AB5 AB6 AB13 AB15 AB16 AB18 AB19 AB21 AB27 AC3 AC4 AC13 AC14 AC15 AC16 AC17 AC18 AC19 AC20 AC21 AD1 AD2 AD3 AD4 AD5 AD7 AD10 AD14 AD17 AD20 AD23 AE1 AE3 AE4 AE10 AE12 AE13 AE15 AE16 AE18 AE19 AE21 AE23 AE24 AF2 AF3 AF4 AF10 AF12 AF13 AF15 AF16 AF18 AF19 AF21 AF24 AG3 AG12 AG13 AG15 AG16 AG18 AG19 AG21 AG22 AG24 AG25 B3 B6 B19 C2 C3 C7 C14 D4 D5 D10 D11 D12 D23 E6 E10 E12 F4 F5 F7 F10 F12 F19 P25 T27 V7 W5 W6 W7 W22 Y3 Y4 Y6; HDA27 10; HDD1 5 7; HDMI1 13 14; IOBD1 16; KB1 2 3; KBBL1 3; LCD1 38; ODD1 8 11; PU4501 15; PU4701 4 6 27 30 31 35; PU4801 4 6 27 30 31 35; PU4802 4 6 27 30 31 35; PU5102 26; PU5301 5; PU8602 12; PU8603 5; RN1704 5; RN4302 1 8; SSD1 6 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67 68; U2502 3; U3101 25; U3601 9; U5501 3; U5802 4 14 22 23 31 32 34 35 58; U6101 3; U7102 6 7 19 20; U7202 4; U7203 2 5; U9103 3 5 9 10 11 12 14 15 25 26 27 28 31 32; VGABD1 2 5; VRAM1 A5 U5; VRAM4 A5 U5; WLAN1 6 8 12 16 20 38 40 42 44 46 48 58 60 62 66 68 70; WWAN1 6 9 10 11; X1801 2

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 4944 vias
v2: diameter 0.356, hole 0.178, TOP to BOTTOM, 1160 vias
v3: diameter 0.559, hole 0.305, TOP to BOTTOM, 24 vias
v4: diameter 0.711, hole 0.406, TOP to BOTTOM, 697 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1V_CPU_CORE: length 45.2
  TOP w0.305: v1(88.09,149.76) PR4631.2
  L5 w0.254: v1(88.09,149.76) 87.27,149.76 85.09,147.58 83.42,147.58 82.91,147.07 82.91,145.85 83.29,145.47 84.08,145.47 84.53,145.01 84.53,143.13 85.19,142.47 85.19,137.77 81.18,133.76 81.18,127.95 80.32,127.09 80.32,127.06 v4(80.09,126.84)
  BOTTOM w0.254: CPU1.BF2 v1(96.12,106.69) ; CPU1.AU6 v1(90.78,103.36) 90.81,103.36 CPU1.AV5 ; CPU1.AW8 v1(92.63,102.09) ; v1(91.29,106.71) 91.24,106.66 CPU1.AV2 ; CPU1.AP2 v1(88.8,106.69) ; CPU1.AW5 v1(92.63,104.01) ; CPU1.AU8 v1(90.78,102.09) ; CPU1.AR5 89.39,103.7 89.74,103.36 v1(89.85,103.36) CPU1.AR6 ; CPU1.AR8 v1(89.85,102.09) ; CPU1.AW6 v1(92.63,103.36) 92.74,103.36 93.09,103.7 CPU1.BA5 ; CPU1.AU7 v1(90.78,102.72) ; CPU1.AR7 v1(89.85,102.72) ; CPU1.AW7 v1(92.63,102.72) ; CPU1.AU5 v1(90.78,104.01) ; CPU1.BA7 v1(93.55,102.72) ; CPU1.AV7 v1(91.7,102.72) ; CPU1.BB2 v1(93.68,106.69) ; CPU1.BA8 v1(93.55,102.09)
  BOTTOM w0.305: v1(94.47,103.36) CPU1.BC6 ; v1(94.47,103.36) CPU1.BD5 ; v1(94.47,103.36) CPU1.BC5 ; CPU1.BC7 v1(94.47,102.72)
  vias: v1(88.05,89.81) v1(88.96,89.81) v1(89.87,89.82) v1(90.78,89.81) v1(91.7,89.81) v1(92.61,89.81) v1(93.52,89.81) v1(94.43,89.81) v1(95.34,89.81) v1(96.25,89.81) v2(76.04,124.1) v2(82.32,116.16) v2(83.82,125.4) v2(89.31,90.88) v2(90.25,101.22) v2(93.2,101.35) v4(73.59,126.72) v4(73.59,125.88) v4(73.59,125.04) v4(73.57,124.2) v4(73.89,123.37) v4(74.48,126.71) v4(74.48,125.87) v4(74.48,125.03) v4(74.45,124.2) v4(74.73,123.37) v4(75.23,127.07) v4(75.57,123.35) v4(76.46,123.35) v4(77.35,123.35) v4(78.24,123.35) v4(78.36,127.01) v4(79.07,123.37) v4(79.25,126.84) v4(79.25,126) v4(79.25,125.04) v4(79.25,124.21) v4(79.91,123.37) v4(80.09,126) v4(80.09,125.04) v4(80.09,124.21) v4(80.75,123.37) v4(80.93,126.84) v4(80.93,126) v4(80.93,125.04) v4(80.93,124.21) v4(81.59,123.37) v4(81.77,126.84) v4(81.77,126) v4(81.77,125.04) v4(81.79,124.21) v4(82.43,123.35) v4(82.59,127.01) v4(83.32,123.35) v4(83.44,127.01) v4(84.2,123.35) v4(85.05,123.35) v4(85.88,96.62) v4(85.91,95.78) v4(85.91,94.95) v4(85.91,94.06) v4(85.91,93.12) v4(85.98,127.05) v4(86.82,127.05) v4(87.53,92.08) v4(88.4,100.26) v4(89.41,100.26) v4(89.46,92) v4(90.4,92) v4(91.19,100.26) v4(92.21,100.26) v4(92.15,92) v4(92.54,98.65) v4(92.54,97.77) v4(92.54,96.9) v4(92.54,95.94) v4(92.54,95.07) v4(92.54,94.24) v4(92.54,93.22) v4(93.14,92.03) v4(93.98,100.26) v4(95,100.26)
1V_GT_CORE: length 3.7
  BOTTOM w0.127: CPU1.AB2 v1(81.45,107.14) ; CPU1.AF2 v1(83.92,107.24)
  BOTTOM w0.254: CPU1.V2 v1(79.04,107.19) ; CPU1.AK2 86.36,106.48 v1(86.19,106.66)
  vias: v1(80.61,102.05) v1(81.55,102.07) v1(82.46,102.05) v1(83.39,102.06) v2(81.71,100.92) v4(80.13,100.26) v4(81.2,100.26) v4(82.83,100.26) v4(83.97,100.26) v4(85.6,100.26)
1V_VCCGT: length 24.8
  L5 w0.305: v1(71.02,144.22) 71.02,143.49 64.32,136.78 64.32,136.02 63.6,135.31 63.43,135.31 62.87,134.75 62.87,134.14 63.22,133.78 63.22,130.58 65.15,128.65 v4(65.15,127.33)
  BOTTOM w0.127: v1(74.2,107.11) 74.15,107.07 CPU1.K2
  BOTTOM w0.152: CPU1.P2 76.6,106.22 76.59,106.23 76.59,107.26 v1(76.51,107.34)
  BOTTOM w0.305: PR4663.1 71.03,144.23 v1(71.02,144.22)
  BOTTOM w0.508: v1(70.36,110.32) 70.54,110.14 R807.1
  vias: v1(68.51,99.04) v1(68.53,97.21) v1(68.59,98.14) v1(68.59,96.26) v1(69.24,98.14) v1(69.24,96.26) v1(69.89,100.03) v1(69.89,98.14) v1(69.89,97.2) v1(69.89,96.26) v1(70.54,100.03) v1(70.54,99.08) v1(70.54,98.14) v1(70.54,97.2) v1(70.54,96.26) v1(71.19,100.03) v1(71.19,98.14) v1(71.19,96.26) v1(71.78,104.34) v1(71.84,100.03) v1(71.84,99.08) v1(71.84,98.14) v1(71.84,97.2) v1(71.84,96.26) v1(72.27,103.43) v1(72.27,102.8) v1(72.49,100.03) v1(72.49,99.08) v1(72.49,98.14) v1(72.49,97.2) v1(72.49,96.26) v1(72.52,95.31) v1(73.14,100.03) v1(73.14,98.14) v1(73.14,96.26) v1(73.18,104.08) v1(73.17,103.44) v1(73.16,102.8) v1(73.79,100.03) v1(74.17,102.8) v1(75.01,102.8) v1(75.11,102.13) v1(75.95,102.8) v1(75.97,102.13) v2(76.53,101.58) v4(64.27,126.67) v4(64.28,125.83) v4(65.06,123.98) v4(65.15,126.49) v4(65.15,125.66) v4(65.17,124.81) v4(65.61,123.34) v4(66.45,123.32) v4(67.29,123.32) v4(68.13,123.29) v4(68.96,123.29) v4(69.8,126.72) v4(69.8,125.86) v4(69.8,124.94) v4(69.8,124.08) v4(69.8,123.24) v4(70.69,126.72) v4(70.69,125.86) v4(70.69,124.94) v4(70.69,124.08) v4(70.69,123.24) v4(75.76,94.49) v4(75.76,93.65) v4(76.6,94.49) v4(76.6,93.65) v4(77.44,94.49) v4(77.44,93.65) v4(78.28,94.49) v4(78.28,93.65) v4(79.11,94.49) v4(79.11,93.65) v4(79.95,94.49) v4(79.95,93.65) v4(80.79,94.49) v4(80.79,93.65) v4(81.63,94.49) v4(81.63,93.65)
1V_VCCIO: length 1.1
  BOTTOM w0.305: CPU1.BP16 101.35,96.58 v1(101.35,96.48) 101.35,96.39 CPU1.BP18
  vias: v1(85.86,91.9) v1(86.22,89.86) v1(87.13,89.85) v1(97.16,89.81) v1(97.29,92.05) v1(97.97,92.08) v1(98.08,89.81) v2(108.21,129.29) v4(107.57,129.47) v4(107.57,128.6) v4(108.08,130.23) v4(108.46,128.58)
1V_VCCSA:
  vias: v1(97.24,102.07) v1(98.17,102.07) v1(98.68,96.83) v1(98.67,91.89) v1(98.96,89.82) v1(99.09,102.07) v1(99.34,98.99) v1(100.02,92.18) v2(91.19,124.51) v2(94.8,124.44) v4(90.3,128.32) v4(90.3,127.43) v4(90.3,126.54) v4(90.3,125.66) v4(95.18,128.32) v4(95.18,127.48) v4(95.18,126.65) v4(95.18,125.81) v4(96.03,128.35) v4(96.03,127.52) v4(96.04,126.65) v4(96.02,125.81) v4(96.65,100.26) v4(97.49,100.26) v4(98.71,99.39) v4(98.71,98.55) v4(98.71,97.59) v4(99.42,100.31) v4(99.44,98.1) v4(99.44,97.08)
1V_VCCST_CPU: length 111.2
  TOP w0.508: v1(121.1,116.3) 121.21,116.19 121.21,115.8 120.7,115.29 118.87,115.29 R4036.2 ; v1(96.73,125.11) 96.75,125.09 96.75,124.3 96.52,124.07 v1(96.52,119.18) C807.1 96.57,117.98 C805.2 ; 96.8,115.73 99.34,113.19 99.34,112.67 99.72,112.29 99.72,111.58 100.13,111.18 100.13,107.93 100.82,107.24 v1(101,107.24) 100.51,106.75 100.51,104.56
  L5 w0.508: v1(96.73,125.11) 96.79,125.11 96.9,124.99 98.67,124.99 99.79,126.11 105.97,126.11 106.71,126.85 106.71,129.9 107.83,131.01 ; 107.83,131.01 v1(108.72,131.01) ; 107.83,131.01 107.5,131.34 107.5,134.53 103.73,138.3 102.32,138.3 101.73,138.89 101.73,139.6 99.95,141.38 99.95,141.79 97.51,144.22 97.51,146.29 97.67,146.44 97.67,147.83 97.18,148.31 v1(97.18,151.11)
  L6 w0.508: v1(116.82,126.44) 116.82,127.18 116.13,127.86 112.61,127.86 112.41,128.07 112.4,128.07 109.45,131.01 v1(108.72,131.01) ; v1(84.59,152.4) 84.59,151.89 85.42,151.06 90.77,151.06 90.9,151.18 91.76,151.18 91.98,151.4 91.99,151.4 92.01,151.42 96.76,151.42 96.89,151.29 97,151.29 v1(97.18,151.11)
  BOTTOM w0.152: v1(101,107.24) CPU1.BP2
  BOTTOM w0.305: v2(93.79,118.94) 91.9,117.04 C801.1 91.72,116.05 R308.1
  BOTTOM w0.508: v2(93.79,118.94) 94.03,119.18 v1(96.52,119.18) ; v1(121.1,116.3) 121.11,116.3 121.11,116.31 121.24,116.43 121.24,119.23 118.27,122.2 118.27,124.99 v1(116.82,126.44)
  vias: v1(100.99,100.77) v1(102.05,100.76)
1V_VCCST_CPU_R: length 0.9
  TOP w0.305: C4012.1 117.37,115.38 R4036.1
  vias: v2(116.26,117.22)
1V_VCCSTG: length 89.4
  TOP w0.254: R310.2 79.79,105.48 78.65,105.48 78.58,105.4 ; 78.58,105.4 78.58,106.16 78.31,106.43 78.31,109.77 75.92,112.16 v1(75.9,112.16) ; 78.58,105.4 78.56,105.39 R311.2 R309.2 R315.2 ; R4038.2 110.07,126.79 109.63,127.23 v1(109.45,127.23)
  L3 w0.254: v1(96.16,107.34) 94.77,108.73 94.77,111.41 93.14,113.03 93.14,113.72 88.85,118.02 88.85,123.17 88.27,123.76 v1(88.27,123.88)
  L5 w0.254: v1(96.16,107.34) 95.68,107.34 94.52,106.17 92.57,106.17 90.38,108.36 90.38,108.94 88.22,111.1 v1(88.22,112.19) ; v1(88.27,123.88) 88.29,123.88 88.67,124.26 98.66,124.26 100,125.61 106.25,125.61 107.88,127.23 v1(109.45,127.23)
  L6 w0.254: v1(88.22,112.19) 81.74,112.19 v1(81.61,112.32)
  BOTTOM w0.254: 75.19,113.84 75.19,112.88 v1(75.9,112.16) ; 75.19,113.84 75.11,113.77 R312.2 R314.2 ; 75.19,113.84 75.87,114.53 C802.1 ; C802.1 78.11,114.43 R313.2 R301.1 ; C802.1 78.21,115.24 v2(78.39,115.42) 78.44,115.37 79.61,115.37 FC8981.1 81.59,113.39 81.59,112.35 v1(81.61,112.32) ; v1(96.16,107.34) 96.3,107.34
1V_VGA_CORE: length 49.3
  TOP w0.305: v1(138.79,80) 138.41,79.62 PR8504.1
  TOP w0.508: R8706.1 111.13,142.83 v2(111.74,142.24) 112.1,141.86 112.55,141.4 115.09,141.4 115.6,140.9 115.6,138.56 116.28,137.87 v1(116.39,137.87)
  L5 w0.305: v4(140.8,98.15) 139.59,96.95 139.59,89.68 137.32,87.4 137.32,81.23 138.55,80 v1(138.79,80)
  L5 w0.508: v4(121.42,127.99) 122.05,128.62 122.05,129.85 121.06,130.84 v1(118.42,130.84)
  L6 w0.508: v1(116.39,137.87) 116.73,137.53 116.73,132.53 v1(118.42,130.84)
  vias: v1(123.68,127.33) v1(124.24,127.9) v1(124.77,128.44) v1(124.83,127.29) v1(124.86,126.13) v1(125.36,129.01) v1(125.4,127.86) v1(125.43,126.7) v1(125.43,125.59) v1(125.99,127.26) v1(125.99,126.13) v1(126.05,123.81) v1(126.56,127.83) v1(126.56,126.7) v1(126.59,125.54) v1(126.62,124.38) v1(126.62,123.25) v1(127.13,127.27) v1(127.15,126.1) v1(127.18,124.95) v1(127.18,123.81) v1(127.72,127.86) v1(127.75,125.51) v1(127.75,124.38) v1(128.05,131.38) v1(128.34,123.79) v1(128.73,131.93) v1(129.07,120.91) v1(129.31,129.82) v1(130.08,130.63) v1(130.08,122.03) v1(130.16,133.36) v1(130.66,122.6) v1(131.25,122.01) v1(131.5,132.01) v1(131.83,122.6) v1(132.84,130.68) v1(132.88,133.45) v1(132.97,136.27) v1(134.34,134.87) v1(134.32,132.02) v1(134.32,129.14) v1(135.72,130.61) v1(135.79,133.48) v1(137.14,131.95) v2(132.44,112.29) v2(139.09,99.32) v2(145.8,105.92) v2(146.94,100.97) v2(148.69,106.55) v4(122.03,127.34) v4(122.61,126.7) v4(123.2,126.1) v4(124.35,124.88) v4(124.94,124.29) v4(125.45,123.32) v4(126.07,122.73) v4(126.73,121.89) v4(127.59,121.26) v4(128.26,120.4) v4(141.86,98.15) v4(142.98,98.17) v4(144.05,98.17) v4(144.55,101.4) v4(144.57,100.32) v4(144.57,99.18) v4(145.21,98.17) v4(145.47,102.64) v4(145.47,101.79) v4(146.31,102.67) v4(146.34,101.79) v4(146.28,98.18) v4(147.2,102.67) v4(147.2,101.78) v4(147.4,98.2) v4(148.06,102.64) v4(148.06,101.8) v4(148.43,103.47) v4(148.45,105.35) v4(148.46,104.35) v4(148.55,98.19) v4(148.97,102.64) v4(148.97,101.8) v4(149.32,105.4) v4(149.35,104.36) v4(149.3,103.52) v4(149.74,98.22) v4(149.78,100.89) v4(149.78,100) v4(149.78,99.11) v4(150.23,105.39) v4(150.23,104.48) v4(150.23,103.52)
1V_VGA_S0: length 16.6
  L3 w0.508: v1(105.69,144.58) 105.69,144.95 107.22,146.48 112.58,146.48 114.18,144.88 118.14,144.88 v4(119.31,143.71)
  BOTTOM w0.508: v1(105.69,144.58) 105.69,144.74 106.07,145.12 R8702.1
  vias: v1(134.15,144.83) v1(134.18,143.66) v1(134.71,146.94) v1(135.04,147.59) v1(135.46,148.06) v2(135.36,151.18) v4(120.22,143.71) v4(121.06,143.74)
1V_VGA_S0_EN: length 43.5
  TOP w0.089: U8801.4 95.47,147.3 95.97,147.8 96.32,147.8 96.74,147.37 v1(96.99,147.37) ; v2(107.45,148.76) v1(107.7,148.26)
  L5 w0.089: v1(104.45,154.71) 103.79,155.37 97.21,155.37 96.68,154.84 96.68,147.69 96.75,147.62 96.75,147.62 v1(96.99,147.37) ; v1(112.92,142.11) 112.64,141.84 110.75,141.84 108.79,143.8 108.79,146.31 107.7,147.4 v1(107.7,148.26) 107.7,148.59 107.81,148.71 107.83,148.71 108.46,149.34 108.46,152.71 108.13,153.04 108.13,154.23 v1(108.66,154.76)
  L6 w0.089: v1(104.45,154.71) 104.97,155.24 108.19,155.24 v1(108.66,154.76)
  BOTTOM w0.089: Q8703.2 107.47,147.02 107.7,147.25 v1(107.7,148.26) ; PU8603.7 112.53,142.5 v1(112.92,142.11)
1V_VGA_S0_PG: length 10
  TOP w0.089: v1(109.2,141.48) 109.1,141.38 R8806.2 ; U8803.1 107.21,147.39 v2(107.41,147.19) 107.45,147.16 v1(107.45,145.81)
  L5 w0.089: v1(109.2,141.48) 109.2,142.83 108.21,143.82 108.21,145.05 v1(107.45,145.81)
  BOTTOM w0.089: v1(109.2,141.48) 109.2,141.66 110.04,142.5 PU8603.2
3V5V_CT1: length 0.9
  TOP w0.127: U4001.12 45.04,132.08 C4001.1
3V5V_CT2: length 3.6
  TOP w0.127: v1(61.24,37.8) v2(61.84,38.39) 61.88,38.43 C4002.1
  BOTTOM w0.127: v1(61.24,37.8) 60.89,37.45 U4004.12
3V_5V_DSW_OK: length 181.6
  TOP w0.089: v1(169.68,78.54) 169.37,78.23 169.37,76.67 171.67,74.37 172.7,73.34 172.7,71.79 173.9,70.59 173.9,68.36 172.91,67.37 172.91,63.43 v1(172.94,63.4) ; v1(68.96,39.63) 69.47,39.12 v2(69.8,39.12) 69.8,39.98 PR5308.2
  L5 w0.089: v1(172.94,63.4) 172.47,62.93 172.47,62.36 172.59,62.23 172.59,62.13 172.62,62.11 172.62,59.51 173.15,58.98 173.15,55.63 174.5,54.28 174.5,52.04 175.88,50.67 175.88,48.75 175.14,48.01 174.02,48.01 172.97,46.96 172.97,43.78 170.61,41.42 169.4,41.42 169.19,41.21 167.18,39.2 158.85,39.2 158.42,39.63 158.42,40.11 157.66,40.87 157.56,40.97 151.67,40.97 151.03,40.34 142.07,40.34 140.49,41.91 132.46,41.91 132.11,42.27 129.53,42.27 127.23,44.57 111.37,44.57 110.12,43.32 106.04,43.32 105.16,42.44 105.16,42 104.69,41.53 104.47,41.53 103.37,40.43 101.49,40.43 101.27,40.2 93.66,40.2 93.08,39.63 93.07,39.63 92.94,39.49 91.3,39.49 91.17,39.63 v1(68.96,39.63) ; v1(161.52,93.35) 161.52,92.33 164.62,89.23 164.62,87.36 167.28,84.7 167.28,79.79 168.53,78.54 v1(169.68,78.54)
  BOTTOM w0.089: 156.62,93.27 156.21,92.86 R2514.2 ; 156.62,93.27 156.83,93.06 D2503.3 158.31,93.06 158.58,92.79 159.09,92.79 159.24,92.93 159.46,92.93 160.49,93.96 161.21,93.96 161.52,93.65 v1(161.52,93.35) ; 156.62,93.27 156.62,93.98 157.32,94.68 U2502.4
3V_5V_EN: length 407
  TOP w0.089: D4001.A 147.81,73.47 R4014.1 147.07,72.82 146.23,71.98 C4009.1 147.03,71.73 R4006.1 148.45,71.91 154.54,65.83 154.54,62.19 156.78,59.95 159.86,59.95 163.32,56.49 v1(165.13,56.49) ; v1(62.13,139.55) 62.26,139.42 62.26,137.77 63.04,136.99 63.04,134.24 63.24,134.04 64.39,134.04 64.54,133.88 PR4516.1 ; v1(30.18,27.26) v2(34.94,32.02) 35.18,32.26 35.18,34.9 v1(35.79,35.51)
  L5 w0.089: v1(102.82,33.8) 102.47,33.45 98.17,33.45 97.45,34.17 97.4,34.17 82.72,34.17 82.18,33.63 81.41,33.63 80.81,34.23 54.69,34.23 52.85,32.4 35.86,32.4 30.71,27.26 v1(30.18,27.26) 30.38,27.05 30.38,26.14 29.77,25.52 22.7,25.52 19.34,28.88 18.88,28.88 15.86,31.9 15.86,35.17 16.35,35.66 16.35,49.27 15.73,49.89 15.73,56.84 21.87,62.97 21.87,63.56 22.24,63.94 22.82,63.94 23.47,64.59 23.47,66.26 25.07,67.86 v1(25.07,68.92) 25.07,69.8 27.47,72.2 27.47,74.32 28.5,75.36 29.18,75.36 29.82,76 36.85,76 37,76 38.86,77.86 38.86,91.38 36.39,93.85 30.72,93.85 30.23,94.34 30.23,99.35 26.57,103 26.57,112.87 27.56,113.86 27.56,115.85 26.87,116.54 26.87,120.33 26.51,120.69 26.51,124.9 30.56,128.94 44.46,128.94 45.18,129.66 45.81,129.66 45.98,129.5 50.87,129.5 55.96,134.59 55.96,138 57.28,139.32 60.84,139.32 61.19,139.68 62,139.68 v1(62.13,139.55)
  L6 w0.089: v1(165.13,56.49) 169.81,51.81 169.81,44.3 169.79,44.25 169.45,43.91 129.4,43.91 127.05,46.25 110.61,46.25 109.57,45.22 105.36,45.22 105.11,45.46 105.11,45.61 104.73,45.99 104.37,45.99 103.05,44.67 103.05,43.92 v1(101.86,42.72)
  BOTTOM w0.089: R4009.1 24.62,69.37 v1(25.07,68.92) ; v1(35.79,35.51) 35.79,37.82 35.61,38 35.61,39.12 PR4504.1 ; v1(102.82,33.8) 102.67,33.95 102.67,35.9 102.3,36.27 102.3,37.97 100.34,39.93 100.34,41.63 101.43,42.72 v1(101.86,42.72)
3V_5V_POK: length 441.9
  TOP w0.089: v1(155.81,90.68) 156.31,90.68 156.85,90.15 157.18,90.15 158.02,89.31 158.02,83.11 158.58,82.55 158.58,82.14 158.48,82.05 158.48,81.34 v1(158.12,80.98) ; R4033.1 80.11,34.32 v1(81.87,34.32) ; v1(167.31,74.32) 167.45,74.19 167.49,74.19 167.74,73.94 167.74,73.39 167.31,72.97 167.31,70.33 165.03,68.05 164.95,68.05 163.78,66.88 163.78,63.43 164.78,62.43 164.78,60.75 v1(166.5,59.03) ; Q1701.2 157.74,71.96 157.34,72.36 157.31,72.36 v1(156.98,72.7) ; v1(39.75,37.52) v2(39.27,38) 39.05,38.22 37.29,38.22 36.74,37.68 36.74,37.31 32.77,33.34 32.77,30.59 29.62,27.44 29.62,27.13 v1(29.09,26.6)
  L5 w0.089: v1(107.6,36.96) 107.6,36.79 106.36,35.55 106.36,35.55 106.15,35.34 103.18,35.34 101.65,33.8 98.33,33.8 97.61,34.53 97.55,34.53 97.54,34.53 96.58,34.53 82.08,34.53 v1(81.87,34.32) 81.59,34.59 54.54,34.59 52.71,32.76 35.81,32.76 35.81,32.76 35.71,32.76 30.81,27.86 30.07,27.86 29.93,27.86 29.57,27.51 29.57,27.08 v1(29.09,26.6) 28.88,26.38 26.68,26.38 26.36,26.06 22.96,26.06 20.42,28.6 20.42,28.86 17.01,32.26 17.01,35.51 16.53,35.99 16.53,49.34 15.91,49.96 15.91,56.76 21.92,62.77 22.53,62.77 22.78,63.02 22.78,63.37 23.64,64.24 23.64,66.19 25.96,68.5 25.96,69.87 26.6,70.51 26.73,70.51 29.23,73.01 29.23,75.11 29.92,75.81 37.06,75.81 39.04,77.78 39.04,91.96 36.83,94.16 36.83,95.59 31.28,101.14 28.68,101.14 26.75,103.08 26.75,112.8 27.76,113.81 27.76,116.16 27.16,116.76 27.16,120.49 26.69,120.97 26.69,124.82 30.62,128.75 44.64,128.75 45.37,129.48 45.72,129.48 45.89,129.32 50.94,129.32 56.21,134.59 56.21,138 57.35,139.14 61.47,139.14 v1(61.57,139.24)
  L6 w0.089: v1(158.12,80.98) 157.69,80.55 157.69,80.16 157.94,79.91 158.32,79.91 158.85,80.44 162.33,80.44 163.32,79.46 163.8,79.46 167.92,75.34 167.92,74.93 v1(167.31,74.32) ; v1(166.5,59.03) 166.9,59.03 168.33,57.6 168.33,57.1 169.99,55.44 169.99,44.2 169.53,43.73 129.3,43.73 126.95,46.08 110.68,46.08 109.64,45.04 105.08,45.04 v1(104.55,45.57)
  BOTTOM w0.089: PU4501.10 60.34,134.82 60.1,135.05 ; v1(155.81,90.68) 156.77,91.64 158.19,91.64 D2503.1 ; v1(104.55,45.57) 104.55,45.24 105.27,44.52 105.27,41.6 105.84,41.02 105.84,38.38 107.27,36.96 v1(107.6,36.96) ; v1(61.57,139.24) 61.57,138.81 62.17,138.22 ED1703.2 61.45,137.1 PR4505.2 61.29,135.21 60.25,135.21 60.1,135.05 ; 60.1,135.05 59.89,134.84 PU4501.9 ; v1(167.31,74.32) 166.73,74.91 163.98,74.91 161.34,72.27 157.4,72.27 v1(156.98,72.7)
3V_5V_POK#: length 3.8
  TOP w0.089: R1726.1 v2(158.98,68.07) ; R1726.1 158.63,69.37 158.39,69.61 Q1701.6 ; R1726.1 158.4,68.96 157.74,69.62 Q1701.5
5V_3V_TPAN_PWR:
  vias: v2(155.76,107.37)
5V_FAN_VCC: length 7.3
  TOP w0.508: v1(160.07,88.7) AFTP2603.1 162.49,88.7 163.22,87.96 C2604.1 163.22,86.45 D2601.K
  BOTTOM w0.508: FAN1.1 160.07,88.7 v1(160.07,88.7)
5V_HDD_S0:
  vias: v1(159.85,39.78) v1(160.57,39.78) v1(161.32,39.78) v2(159.82,38.84)
5V_HDMI: length 8.7
  TOP w0.508: v1(14.96,102.59) 15.49,102.07 16.8,102.07 C5736.2 16.82,101.4 F5701.2
  BOTTOM w0.508: HDMI1.18 13.95,103.35 14.71,102.59 v1(14.96,102.59) ; v2(15.04,101.93) 15.04,102.52 v1(14.96,102.59) ; U5702.2 15.28,102.91 v1(14.96,102.59)
5V_IRLED: length 10.8
  TOP w0.254: F5506.2 223.27,41.12 221.17,41.12 220.75,41.53 220.75,41.61 220.09,42.27 219.48,42.27 219.23,42.01 AFTP5512.1 C5504.1 218.98,43.89 219.54,44.46 219.54,44.63 219.71,44.81 219.71,45.19 220.14,45.62 v1(220.22,45.62)
  BOTTOM w0.305: LCD1.24 220.15,45.55 v1(220.22,45.62)
5V_ODD_S0:
  vias: v1(185.63,34.25) v1(190.43,34.06)
5V_S0: length 468.1
  TOP w0.305: FC8916.1 81.08,37.81 EC8935.1 82.47,38.59 v4(82.48,38.58) ; F5506.1 224.61,40.87 224.41,40.66 v1(224.41,40.16) ; FC8902.1 195.79,64.87 v1(195.66,65) ; Q5701.G 20.87,93.22 FC8903.1 ; R2703.2 18.88,11.15 19.1,11.38 v1(19.13,11.38)
  TOP w0.508: v4(19.36,92.94) 20.57,92.94 Q5701.G ; v4(19.36,92.94) 18.92,93.37 18.92,96.94 18.82,97.04 18.82,97.04 18.27,97.6 18.27,97.69 17.1,98.86 F5701.1 v1(17.1,100.24) ; v4(19.36,92.94) 18.7,92.28 D5701.3 ; EC8936.1 205.26,60.3 v1(205.44,60.48) ; v1(150.37,79.82) 148.83,81.36 PR8551.1 ; v1(203.33,32.82) 203.33,35.69 204.19,36.55 EC6601.1 204.19,38.51 202.85,39.85 v1(202.85,41.15) ; v1(183.35,70.13) 182.26,70.58 182.21,70.69 179.96,71.62 177.11,72.8 168.1,81.81 168.1,83.54 167.72,83.92 v2(167.72,84.86) FC8915.1 165.59,85.78 R5502.1 165.26,85.88 164.11,87.02 164.11,88.24 162.95,89.41 v1(160.07,89.41) 159.54,89.41 R2612.1 ; R7014.1 139.46,91.3 139.6,91.16 139.6,90.22 139.27,89.89 139.09,89.71 v1(138.81,89.71)
  L5 w0.305: v1(202.85,41.15) 204.32,41.15 206.07,42.9 208.07,42.9 210.37,45.2 210.37,45.65 211.83,47.11 v1(211.83,47.97)
  L5 w0.508: v1(217.15,62.84) 217.15,63.02 217.6,63.47 218.72,63.47 219.17,63.02 219.26,63.02 222.46,59.83 222.46,53.93 221.6,53.07 221.6,40.79 222.23,40.16 v1(224.41,40.16) ; v1(30.52,69.94) 30.52,69.56 28.17,67.21 28.17,66.14 26.34,64.31 26.34,60.47 24.5,58.62 23.34,58.62 19.87,55.15 19.87,50.12 18.91,49.16 18.91,37.25 20.17,35.99 20.17,32.67 21.45,31.4 26.69,31.4 27.68,32.39 31.53,32.39 34.47,35.32 34.55,35.32 36.77,37.54 36.77,38.32 39.93,41.48 51.51,41.48 54.82,38.17 54.82,37.52 56.07,36.26 60.57,36.26 v4(61.34,37.03) ; v1(138.81,89.71) 136.78,87.68 136.78,80.99 140.32,77.45 143.44,77.45 144.42,78.43 147.88,78.43 149.26,79.82 v1(150.37,79.82)
  L6 w0.381: v1(19.13,11.38) 19.03,11.38 18.77,11.13 18.77,7.14 20.42,5.49 20.42,4.93 21.34,4.01 23.63,4.01 24.09,4.48 34.31,4.48 35.8,5.98 35.8,12.1 34.55,13.36 v4(34.55,18.81)
  L6 w0.508: v1(183.35,70.13) 183.53,69.69 183.97,69.24 185.55,69.24 186.62,68.87 187.54,68.5 189.8,66.24 195.05,66.24 195.66,65.63 v1(195.66,65) ; v4(82.48,38.58) 83.19,37.87 90.86,37.87 91.44,38.46 100.66,38.46 v1(101.6,39.4) ; 208.22,31.41 211.33,31.41 212.41,31.69 213.82,33.1 213.82,33.96 215.29,35.43 217.46,35.43 218.29,34.6 222.82,34.6 225.4,37.19 225.4,39.43 224.67,40.16 v1(224.41,40.16) ; v1(150.37,79.82) 150.37,80.27 150.78,80.67 155.43,80.67 159.41,84.66 159.41,89 159.82,89.41 v1(160.07,89.41) ; v1(217.15,62.84) 217.15,62.45 215.84,61.14 206.1,61.14 v1(205.44,60.48)
  L6 w0.762: 61.32,35.79 60.09,34.56 55.32,34.56 52.74,31.97 40.46,31.97 38.6,30.11 36.15,30.11 33.4,27.37 v3(33.4,27.23)
  BOTTOM w0.203: ED5502.5 212.77,47.97 v1(211.83,47.97)
  BOTTOM w0.305: v1(101.6,39.4) 101.33,39.67 Q6505.E
  BOTTOM w0.508: ED6601.5 203.71,41.15 v1(202.85,41.15) ; v1(30.52,69.94) 30.58,70 30.58,71.71 32.22,73.35 34.69,73.35 34.74,73.4 34.76,73.4 35.25,73.89 36.56,73.89 36.95,74.28 37.19,74.52 38.06,74.52 38.6,75.06 43.07,75.06 43.43,75.06 43.66,74.83 48.8,74.83 50.94,76.96 50.94,77.55 51.39,78 52.53,78 52.86,78.33 52.86,87.87 53.48,88.49 53.48,89.79 51.87,91.4 v2(43.16,91.4) 39.21,91.4 37.79,92.82 25.64,92.82 25.17,92.36 21.72,92.36 21.14,92.94 v4(19.36,92.94) ; v1(17.1,100.24) 17.1,100.76 18.29,101.96 U5702.3
  BOTTOM w0.762: F6501.1 82.24,37.46 82.48,37.69 v4(82.48,38.58)
  vias: v1(155.16,33.81) v1(155.81,33.81) v1(156.44,33.81) v1(157.08,33.81) v2(35.44,18.95) v2(63.12,36.12) v2(155.73,34.82) v2(190.45,31.62) v3(190.45,32.49) v4(34.55,19.65) v4(62.18,37.03) v4(63.02,37.03)
5V_S5: length 349.8
  TOP w0.203: U4001.4 48.02,132.48 48.09,132.41 v1(48.8,132.41)
  TOP w0.254: v3(20.2,122.28) 20.22,122.3 EC8949.1 ; v3(20.14,121.59) 20.2,121.54 FC8917.1 ; v1(16.89,51.11) 17.37,51.11 R3606.1 R3602.1 ; 49.8,40.91 45.91,40.91 44.65,39.65 PG4527.2
  TOP w0.305: U4006.3 111.44,116.57 110.95,116.08 C4031.1 111.53,115.22 113.16,113.59 113.16,112.92 113.69,112.4 v1(113.76,112.4) ; R4303.1 18.29,99.39 v1(18.29,98.78) EC8948.1 ; EC8947.1 16.56,89.56 v4(16.21,89.21) ; v1(17,54.92) 17.32,54.92 17.65,54.92 R3605.1
  TOP w0.406: v1(94.75,72.57) 95.51,72.57 C4041.1 96.04,72.77 96.43,73.16 U4003.3 ; U4002.3 108.24,120.87 108.48,120.63 C4032.1 108.48,119.87 108.58,119.77 v1(108.58,119.76)
  TOP w0.508: v1(108.69,135.36) 109.02,135.03 109.02,132.01 116.02,125.01 117.67,125.01 v1(119.28,123.39) ; 74.74,139.33 75.3,139.33 75.77,139.8 75.77,141.3 75.37,141.71 68.41,141.71 68.1,141.4 v1(67.31,141.4) 67.31,140.07 64.27,137.03 PC4766.1 v1(63.47,135.94) ; v1(115.24,112.9) 121.27,112.9 121.9,112.27 v1(123.62,112.27) ; v1(90.5,145.47) PR4670.2 90.5,141.35 87.25,138.1 84.92,138.1 82.91,136.09 81.59,136.09 81.11,135.61 PC4877.1 80.57,136.3 v1(80.44,136.42) 79.61,136.42 PR4803.2
  L3 w0.508: v1(113.76,112.4) 113.71,112.45 113.49,112.45 113.12,112.82 113.12,113.35 113.13,113.35 113.13,114.25 108.53,118.85 108.53,119.72 v1(108.58,119.76)
  L5 w0.508: v1(129.7,117.6) 130.33,117.6 133.2,114.73 135.33,114.73 139.36,110.71 145.54,110.71 146.99,112.17 152.35,112.17 152.61,112.42 158.78,112.42 159.21,111.99 162.44,111.99 163.15,111.28 166.45,111.28 167.21,110.52 167.21,109.37 ; v1(113.76,112.4) 114.73,112.4 v1(115.24,112.9) ; v1(158.45,102.87) 159.01,102.87 162.46,106.33 165.36,106.33 166.78,107.75 166.78,108 167.21,108.43 167.21,109.37 ; 167.21,109.37 v1(166.53,109.37)
  L6 w0.254: v1(100,44.45) 99.42,45.04 99.42,46.44 99.43,46.45 99.43,48.6 91.32,56.72 91.32,63.68 95.38,67.74 95.38,72.32 95.13,72.57 v1(94.75,72.57)
  L6 w0.305: v1(194.69,35.54) 196.6,37.44 196.6,38.99 198.56,40.95 201.24,40.95 201.6,40.59 204,40.59 206.24,42.83 208,42.83 208.77,43.6 208.77,44.1 208.11,44.75 206.08,44.75 205.67,45.16 205.67,48.72 205.87,48.92 205.87,49.06 206.09,49.28 206.24,49.28 206.33,49.37 206.34,49.37 207.14,50.17 207.14,50.93 204.55,53.52 199.14,53.52 197.89,54.76 196.23,54.76 195.63,55.36 v1(195.63,55.47) ; v1(48.8,132.41) 49.24,132.41 49.73,131.93 50.08,131.93 50.63,131.38 50.63,130.86 51.69,129.8
  L6 w0.508: v1(99.7,138.74) 99.43,138.09 99.32,137.97 ; v1(108.69,135.36) 106.63,135.36 104.98,137.01 100.28,137.01 99.32,137.97 ; 99.32,137.97 97.57,137.97 90.76,144.78 90.66,144.78 90.5,144.93 v1(90.5,145.47) 89.69,146.28 89.69,147.13 88.68,148.14 86.61,148.14 86.26,148.49 ; v3(44.25,123.62) 45.17,124.54 45.17,125.25 48.8,128.87 50.77,128.87 53.34,131.45 53.34,131.8 56.78,135.24 62.76,135.24 v1(63.47,135.94) ; v1(80.83,155.12) 80.83,153.49 83.25,151.07 83.25,150.69 ; v1(80.44,136.42) 79.51,137.36 74.74,137.36 v1(74.13,136.75)
  BOTTOM w0.203: U8601.4 v1(166.53,109.37)
  BOTTOM w0.254: v1(98.48,39.6) 98.48,42.93 v1(100,44.45)
  BOTTOM w0.305: v1(63.47,135.94) 63.76,135.94 63.8,135.9 PU4701.29 ; PU4802.29 74.47,135.96 74.13,136.29 v1(74.13,136.75) ; PU4801.29 80.76,136.01 80.44,136.32 v1(80.44,136.42) ; v1(195.63,55.47) 195.63,54.99 Q6405.E ; Q6404.E 14.42,108.43 v1(11.69,108.43) ; PR4610.1 77.7,155.04 78.06,155.4 80.55,155.4 v1(80.83,155.12)
  BOTTOM w0.508: v1(119.28,123.39) 119.13,123.24 119.13,122.53 v2(121.31,120.35) 121.49,120.35 124.89,116.94 ; 124.89,116.94 124.69,116.73 124.69,113.61 123.62,112.55 v1(123.62,112.27) ; 124.89,116.94 125.43,117.48 128.63,117.48 128.76,117.6 v1(129.7,117.6) ; v1(98.96,37.73) 98.96,37.72 98.2,36.96 PU5101.6 ; PR4704.2 67.34,141.38 v1(67.31,141.4) ; v1(11.69,108.43) 11.69,109.24 Q6403.E ; 154.87,103.56 154.87,103.1 155.72,102.25 157.39,102.25 158.02,102.87 v1(158.45,102.87)
  vias: v1(18.57,35.1) v1(18.57,34.47) v1(18.57,33.83) v1(20.07,38.79) v1(48.4,40.02) v1(57.89,37.79) v1(110.19,29.28) v1(128.81,34.25) v1(129.32,33.74) v1(129.8,33.32) v1(171.01,39.42) v1(193.37,35.54) v1(194.03,35.54) v2(20.25,28.14) v2(24.54,44.2) v3(15.27,113.13) v3(15.27,112.45) v3(19.41,122.28) v3(23.13,29.9) v3(43.86,124.19) v3(43.93,123.02) v3(95.05,32.7) v4(15.83,88.06) v4(16.36,28.6) v4(16.56,24.97) v4(16.56,24.11) v4(16.81,88.05) v4(17.44,24.96) v4(17.43,24.11) v4(18.6,26.7) v4(20.09,38.05) v4(20.09,37.21) v4(23.45,30.59) v4(23.93,29.89) v4(24.29,30.66) v4(24.77,29.89) v4(25.12,30.66) v4(49.15,39.93) v4(49.98,39.96) v4(50.82,39.96) v4(55.55,37.92) v4(56.29,38.36) v4(56.31,37.52) v4(149.76,35.69) v4(170.26,39.45)
5V_TPAN_PWR: length 25.2
  TOP w0.508: R5502.2 165.48,87.68 v1(165.87,88.06)
  L6 w0.508: v1(159.11,106.81) 159.11,105.02 157.61,103.52 157.61,98.22 162.31,93.52 164.33,93.52 166.12,91.74 166.12,88.32 v1(165.87,88.06)
  vias: v2(159.74,106.57)
5V_TPAN_VDD: length 126.4
  TOP w0.305: AFTP5513.1 182.86,69.61 v1(182.89,69.58)
  L3 w0.508: v1(182.89,69.58) 183.54,68.93 186.08,68.93 186.81,68.78 187.57,68.45 189.68,66.35 209.05,66.35 209.69,66.99 219.85,66.99 221.21,68.35 223.22,68.35 224.54,67.03 224.54,61.52 223.6,60.58 223.6,45.94 v1(224.41,45.14)
  L6 w0.508: v1(160.81,109.02) 160.81,105.73 159.34,104.26 159.34,102.86 158.5,102.02 158.5,98.23 162.27,94.46 165.29,94.46 167.52,92.24 167.52,81.46 169.29,79.68 169.74,79.68 175.03,74.39 ; 176.36,73.36 176.74,72.98 178.26,72.98 180.14,71.1 180.89,71.1 182.54,70.41 v1(182.89,69.58) ; v1(224.41,45.14) 224.41,45.14 223.98,45.57 221.29,45.57 220.64,44.92 v1(220.23,44.92)
  BOTTOM w0.305: LCD1.25 220.1,45.05 v1(220.23,44.92)
5V_USB30_VCCA: length 2.5
  TOP w0.508: 13.14,35.64 USB2.1 14.46,34.5
  vias: v1(15.93,37.26) v1(15.93,36.6) v1(15.93,35.94)
5V_VCONN_EN: length 1.3
  TOP w0.089: U7202.3 46.15,124.48 45.96,124.3 R7205.2
5V_VCONN_P1:
  vias: v2(49.15,125.78)
5V_VCONN_P1_CCG4: length 19.2
  TOP w0.305: v1(43.21,111.23) 43.2,111.23 43.13,111.16 U7201.5 ; v2(49,122.71) R7203.2
  TOP w0.508: v1(49.69,123.7) 49.66,123.67 49.45,123.67 49.4,123.62 R7203.2
  L5 w0.508: v1(43.21,111.23) 43.2,111.23 43.2,112.51 44.33,113.64 44.33,115.29 45.24,116.21 45.27,116.21 46.02,116.96 47.73,116.96 48.69,117.92 48.69,118.21 50.37,119.89 50.37,123.28 49.97,123.67 49.71,123.67 v1(49.69,123.7)
19V_AD+: length 369.3
  TOP w0.254: v1(210.5,43.59) 210.37,43.46 PR4473.1
  TOP w0.356: v2(28.65,96.04) 28.71,96.09 v1(29.26,96.09)
  L3 w0.305: v1(29.26,96.09) 29.57,96.09 30.08,95.58 30.08,94.34 31.14,93.28 39.27,93.28 40.49,92.06 40.49,77.09 36.73,73.33 35.66,73.33 34.81,72.48 34.27,72.48 30.25,72.48 28.84,71.07 26.47,71.07 24.49,69.09 24.49,67.13 24.26,66.9 24.26,62 24.12,61.86 24.12,61.84 22.81,60.53 22.81,59.08 19.73,56.01 19.73,49.57 19.4,49.24 19.4,42.86 18.82,42.28 18.82,36.86 19.94,35.74 19.94,29.42 23.71,25.66 30.62,25.66 31.85,24.42 31.85,24.12 32.17,23.8 v1(32.17,23.42)
  L5 w0.152: v1(202.57,33.45) 198.87,33.45 197.23,31.81 174.9,31.81 173.98,32.74 171.91,32.74 170.97,31.8 148.61,31.8 147.23,33.17 145.32,33.17 144.72,32.58 137.6,32.58 136.88,33.29 135.1,33.29 131.86,36.53 130.31,36.53 124.53,42.3 112.4,42.3 111.24,41.15 111.24,37.53 110.56,36.86 110.56,35.81 109.08,34.33 109.08,33.74 106.42,31.08 90.59,31.08 89.23,29.72 37.71,29.72 35.69,27.69 35.69,26.33 34.44,25.08 33.82,25.08 v1(32.17,23.42)
  L5 w0.305: v1(29.26,96.09) 29.24,96.11 28.71,96.11 27.74,97.09 27.74,97.51 27.69,97.57 27.69,97.65 23.75,101.59 23.75,107.49 23.24,108 23.24,110.92 24.29,111.96 24.29,119.58 23.41,120.46 23.41,123.79 30.38,130.76 v4(30.38,132.11)
  L6 w0.305: v1(198.83,40.42) 200.31,38.94 204.88,38.94 v1(205.49,38.33) 205.49,39.4 205.84,39.75 207.86,39.75 209.15,41.04 209.15,42.33 210.4,43.59 v1(210.5,43.59)
  BOTTOM w0.152: v1(205.49,38.33) 202.57,35.41 v1(202.57,33.45)
  BOTTOM w0.254: PR4464.2 192.59,42.5 PR4465.1 192.74,42.19 195.04,39.89 PD4408.1 196.43,40.42 v1(198.83,40.42) 198.83,40.59 PD4401.1
20V_DCBATOUT: length 6.9
  TOP w0.508: v1(196.85,54.14) 196.87,54.13 v2(196.87,53.47) PR4439.1
  BOTTOM w0.406: PU4403.5 194.35,54.12 195.66,52.81 196.42,52.81 196.75,53.14 196.75,54.04 v1(196.85,54.14)
20V_VCCPD_VBUS: length 48.5
  TOP w0.254: C7306.1 11.59,120.12 11.59,118.76 10.94,118.11 v1(10.67,118.11)
  TOP w0.305: v1(10.67,118.11) 10.67,116.38 AFTP7302.1 10.54,113.72 v1(10.62,113.64) ; v1(44.53,107.11) 44.66,107.24 R7201.2
  L3 w0.508: JUSB1.B9 7.78,122.4 ; JUSB1.B4 7.76,125
  L6 w0.508: v1(44.53,107.11) 44.22,107.11 42.7,105.59 33.23,105.59 32.24,104.6 32.24,102.11 31.78,101.66 28.38,101.66 27,103.03 27,106.93 24.29,109.65 v1(24.29,110.46)
  BOTTOM w0.254: R7426.1 R7425.1 24.08,109.5 24.08,110.26 v1(24.29,110.46)
  BOTTOM w0.305: R7423.1 27.23,116.1 26.65,115.52 26.22,115.52 v1(25.66,114.96) ; JUSB1.B9 6.76,122.45 JUSB1.A4 ; C7305.1 10.72,113.54 v1(10.62,113.64) ; JUSB1.A9 6.76,124.95 JUSB1.B4
  vias: v1(10.44,124.77) v2(12.04,124.72) v4(39.17,127.31) v4(40.01,127.31) v4(40.9,127.31) v4(41.74,127.33)
20V_VCCPD_VBUS_R: length 6.9
  TOP w0.089: R7201.1 45.8,107.8 45.98,107.98 v2(46.38,107.98) 46.64,107.98 46.74,108.08 R7213.2 46.66,108.81 C7201.2 45.49,108.81 44.8,109.51 43.48,109.51 42.83,110.16 U7201.3
+1.8VALW_EC: length 3.7
  TOP w0.203: U2401.54 33.55,57.71 33.4,57.56 C2423.1 33.84,57.15 34.19,56.8 v2(34.19,56.57) 33.99,56.36 R2462.1
+3V_1D8V_DVDD: length 25.7
  TOP w0.203: HDA27.8 25.93,16.65 25.45,17.12 ; v1(29.47,16.18) 29.39,16.26 HDA27.1
  TOP w0.305: 25.45,17.12 25.28,17.3 C2741.1 24.67,17.3 24.29,17.68 v1(24.14,17.68) ; v1(21.49,21.21) 21.49,20.63 R2710.1 ; C2720.1 C2723.1 30.23,17.65 C2721.1 30.25,17.58 R2717.1 29.57,16.18 v1(29.47,16.18)
  TOP w0.508: C2720.1 C2740.1 29.21,20.58 C2736.1 28.81,21.69 28.66,21.54 R2715.2 27.64,21.54 v2(27.38,21.79)
  BOTTOM w0.508: v1(29.47,16.18) 30.13,16.84 30.13,17.17 28.65,18.64 25.3,18.64 ; 25.3,18.64 24.38,17.73 24.23,17.73 24.18,17.68 v1(24.14,17.68) ; 25.3,18.64 23.37,20.58 21.89,20.58 21.49,20.97 v1(21.49,21.21)
