# Allegro board 18750-1.1227WZS1652.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BOT_MUX_N: length 33.4
  TOP w0.114: EL7106.2 36.56,115.86 36.34,115.64 36.34,115.37 ; v1(36.56,112.85) 36.34,113.07 36.34,115.37 ; v2(36.6,115.37) 36.34,115.37
  L6 w0.102: v1(15.7,119.75) 15.92,119.53 22.2,119.53 24.97,116.77 v1(26.03,116.77)
  BOTTOM w0.114: v1(15.7,119.75) 15.55,119.6 15.24,119.6 15.12,119.72 15.12,120.42 14.86,120.68 14.18,120.68 14,120.85 ED7313.2 13.24,120.85 13.05,120.66 12.23,120.66 R7334.2 ; v1(26.03,116.77) 26.26,116.54 26.53,116.54 26.96,116.97 29.1,116.97 30.32,115.75 34.52,115.75 36.36,113.91 36.36,113.05 v1(36.56,112.85)
BOT_MUX_N_L: length 3.4
  TOP w0.114: 36.15,118.7 35.06,118.7 34.97,118.79 U7102.9 ; 36.15,118.7 36.3,118.7 36.56,118.44 EL7106.1 ; 36.15,118.7 v2(36.15,118.85)
BOT_MUX_N_R: length 7.5
  TOP w0.114: R7333.1 v1(10.49,121.26) 10.06,120.82 9.88,120.82 ; 9.88,120.82 9.41,120.82 7.51,122.72 7.51,122.97 7.18,123.3 JUSB1.B7 ; 9.88,120.82 v2(9.88,120.68)
  BOTTOM w0.114: v1(10.49,121.26) 10.24,121.01 10.24,120.78 10.34,120.68 10.85,120.68 R7334.1
BOT_MUX_P: length 33.2
  TOP w0.114: v2(35.97,113.49) 36.11,113.49 ; 36.11,113.49 36.11,115.64 35.88,115.86 EL7106.3 ; 36.11,113.49 36.11,113.03 v1(35.92,112.85)
  L6 w0.102: v1(15.7,119.11) 15.92,119.33 22.12,119.33 24.89,116.56 25.53,116.56 25.66,116.43 25.66,116.26 25.79,116.13 v1(26.03,116.13)
  BOTTOM w0.114: R7335.2 12.23,120.44 13.02,120.44 13.21,120.24 ED7314.2 13.95,120.24 14.15,120.45 14.76,120.45 14.89,120.32 14.89,119.63 15.15,119.37 15.45,119.37 v1(15.7,119.11) ; v1(35.92,112.85) 36.13,113.05 36.13,113.82 34.42,115.52 30.23,115.52 29.01,116.74 27.05,116.74 26.62,116.31 26.21,116.31 v1(26.03,116.13)
BOT_MUX_P_L: length 3.1
  TOP w0.114: EL7106.4 35.88,117.86 36.01,117.98 36.21,117.98 36.34,118.11 36.34,118.35 36.21,118.47 35.06,118.47 34.97,118.39 U7102.8
BOT_MUX_P_R: length 7.7
  TOP w0.114: R7332.1 v1(9.73,121.26) 9.29,121.26 7.74,122.81 7.74,123.06 7.33,123.47 7.33,124.13 7.14,124.32 6.92,124.32 JUSB1.B6
  BOTTOM w0.114: R7335.1 10.82,120.45 10.25,120.45 10.13,120.57 ; v1(9.73,121.26) 10.01,120.98 10.01,120.68 10.13,120.57 ; 10.13,120.57 v2(10.02,120.46)
BPM_CPU_N0: length 6.3
  BOTTOM w0.089: CPU1.U1 78.38,106.98 77.05,108.31 75.89,108.31 75.06,109.15 75.06,110.03 TP307.1
BPM_CPU_N1: length 5.3
  BOTTOM w0.089: TP308.1 76.35,108.49 77.24,108.49 78.64,107.09 78.64,106.17 78.38,105.91 CPU1.U2
BPM_CPU_N2: length 7.8
  BOTTOM w0.089: TP302.1 74.81,110.03 74.81,109.02 75.69,108.14 76.98,108.14 77.98,107.13 77.98,105.77 78.38,105.37 CPU1.U3
BPM_CPU_N3: length 7.3
  BOTTOM w0.089: TP303.1 75.61,107.96 76.9,107.96 77.55,107.31 77.55,105.34 77.73,105.16 78.01,105.16 78.11,105.06 78.11,104.81 CPU1.U4
BREATH_LED#: length 12.6
  TOP w0.089: U2402.1 43.32,53.02 R2467.1 43.09,53.3 v2(42.12,54.27) 42.12,59.97 41.16,60.94 41.16,61.3 40.36,62.09 U2401.70
BT+: length 80.7
  TOP w0.305: PR4452.1 211.64,45.85 211.05,46.43 210.19,46.43 209.3,47.32 209.3,48.13 208.89,48.54 v1(208.66,48.54) ; v1(143.64,36.5) 143.77,36.63 AFTP4312.1 ; AFTP4313.1 v4(173.38,31.68)
  L3 w0.254: v1(199.44,31.75) 198.54,30.84 189.66,30.84 189.06,31.45 173.61,31.45 v4(173.38,31.68) ; v1(208.66,48.54) 208.94,48.54 209.3,48.19 209.3,47.01 211.93,44.38 211.93,41.29 214,39.22 v1(214,38.26)
  L5 w0.254: v1(199.44,31.75) 199.62,31.93 208.31,31.93 208.71,31.53 212.08,31.53 214,33.45 v1(214,38.26)
  L5 w0.305: v1(208.66,48.54) 208.66,49.4 207.01,51.06 205.67,51.06 204.8,50.18 204.8,48.09 204.14,47.42 204.06,47.42 202.47,45.83 202.47,45.65 v1(200.6,43.79)
  BOTTOM w0.508: PR4478.2 v1(200.6,43.79)
  vias: v4(151.49,33.83) v4(152.35,33.83) v4(172.52,31.68)
BT_PCMFRM_RSTN: length 6.1
  TOP w0.114: R6122.1 35.66,105.69 v2(35.93,105.96) 35.93,106.6 R1913.1 35.29,107.24 v1(34.34,107.24)
  BOTTOM w0.114: WLAN1.10 33.2,105.92 34.34,107.06 v1(34.34,107.24)
BT_PCMOUT_CLKREQ0: length 8.9
  TOP w0.089: v1(34.34,106.25) 34.34,105.82 R6121.1 32.93,105.6 v2(32.93,105.9) 32.92,105.91 32.92,106.38 33.05,106.5 33.05,107.67 33.65,108.27 35.08,108.27 R1912.1
  BOTTOM w0.089: WLAN1.14 34.2,106.11 v1(34.34,106.25)
BT_USB20_CON_N: length 8.7
  TOP w0.114: v1(30.75,95.07) 30.01,95.07 29.75,95.33 29.75,97.51 29.86,97.63 ; 29.86,97.63 AFTP6111.1 ; 29.86,97.63 30.27,98.03 R6105.1
  BOTTOM w0.114: WLAN1.5 31.95,95.48 31.54,95.07 v1(30.75,95.07)
BT_USB20_CON_P: length 8.4
  TOP w0.114: v1(30.75,95.71) 30.34,95.3 30.1,95.3 29.98,95.43 29.98,95.86 ; 29.98,95.86 29.98,97.42 30.36,97.8 30.58,97.8 30.71,97.67 30.71,97.37 30.84,97.25 R6104.1 ; 29.98,95.86 AFTP6114.1
  BOTTOM w0.114: WLAN1.3 31.45,96.8 31.72,96.53 31.72,95.58 31.45,95.3 31.15,95.3 v1(30.75,95.71)
BT_USB20_N: length 125.8
  TOP w0.114: v1(38.09,96.66) 37.87,96.45 37.31,96.45 36,97.75 35.03,97.75 ; 35.03,97.75 33.03,97.75 32.81,97.98 EL6101.2 ; 35.03,97.75 v2(35.03,97.89)
  L6 w0.102: v1(107.89,110.92) 108.15,111.18 108.55,111.18 108.79,111.42 108.79,113.05 109.13,113.38 109.13,114.35 109.51,114.73 109.71,114.73 110.1,114.35 110.1,111.62 110.53,111.19 110.53,109.39 111.21,108.71 112.34,108.71 112.74,109.11 112.74,114.47 110.35,116.87 109.08,116.87 106.29,119.66 103.01,119.66 101.07,121.6 90.49,121.6 89.85,120.96 88.14,120.96 86.57,119.38 66.13,119.38 61.31,114.56 55.33,114.56 54.62,113.84 51.97,113.84 49.89,111.76 48.59,111.76 48.14,111.3 48.14,109.51 45.86,107.23 45.86,105.99 44.14,104.27 40.69,104.27 39.98,103.56 39.98,97.66 38.76,96.45 38.31,96.45 v1(38.09,96.66)
  BOTTOM w0.076: 106.41,108.4 106.41,108.38 106.39,108.35 106.39,107.65 106.44,107.59 106.44,106.93 106.29,106.78 106.29,106.38 106.32,106.3 106.32,106.02 106.29,105.94 106.29,105.73 106.44,105.38 106.54,105.28 CPU1.CC3
  BOTTOM w0.114: v1(107.89,110.92) 107.89,111.06 107.75,111.2 107.51,111.2 107.38,111.08 107.38,109.51 106.41,108.55 106.41,108.4
BT_USB20_P: length 126.1
  TOP w0.114: 36.54,96.89 37.21,96.22 37.9,96.22 v1(38.09,96.03) ; 36.54,96.89 v2(36.45,96.79) ; 36.54,96.89 35.9,97.52 33.01,97.52 32.78,97.3 EL6101.3
  L6 w0.102: v1(107.89,111.68) 108.19,111.38 108.46,111.38 108.59,111.51 108.59,113.13 108.92,113.47 108.92,114.43 109.43,114.94 109.8,114.94 110.3,114.43 110.3,111.71 110.73,111.27 110.73,109.48 111.3,108.92 112.25,108.92 112.54,109.2 112.54,114.39 110.26,116.66 108.99,116.66 106.2,119.45 102.93,119.45 100.99,121.4 90.57,121.4 89.93,120.75 88.22,120.75 86.65,119.18 66.22,119.18 61.39,114.35 55.41,114.35 54.7,113.64 52.06,113.64 49.97,111.56 48.68,111.56 48.34,111.22 48.34,109.43 46.06,107.15 46.06,105.9 44.22,104.07 40.78,104.07 40.19,103.47 40.19,97.58 38.85,96.24 38.3,96.24 v1(38.09,96.03)
  BOTTOM w0.076: 106.19,108.4 106.19,108.38 106.21,108.35 106.21,107.57 106.27,107.52 106.27,107.01 106.11,106.85 106.11,106.35 106.12,106.32 106.14,106.27 106.14,106.05 106.11,105.97 106.11,105.69 106.26,105.34 106.26,104.81 CPU1.CC4
  BOTTOM w0.114: 106.19,108.4 106.19,108.64 107.15,109.61 107.15,111.17 107.41,111.43 107.64,111.43 v1(107.89,111.68)
C10_GATE: length 8.9
  TOP w0.508: R4040.2 90.4,39.8 90,39.4 R4034.2 ; v2(88.68,39.28) 88.8,39.4 R4034.2 ; R4010.2 R4048.2 89.46,37.24 89.61,37.39 v1(89.61,38.53) R4034.2
  BOTTOM w0.356: v1(89.61,38.53) 89.49,38.66 89.49,39.87 89.16,40.2 U4007.2
CAD_SNK_MUX: length 2.6
  TOP w0.089: U7101.29 19.32,107.99 v1(19.28,108.03) v2(18.93,108.52)
  BOTTOM w0.089: v1(19.28,108.03) 19.28,108.51 19,108.79 R7189.2
CAM_EN: length 102.2
  TOP w0.089: v2(157.61,102.85) 157.79,102.85 158.47,103.53 v1(158.6,103.53)
  L3 w0.089: v1(108.33,101.45) 108.77,101.89 108.77,102.21 108.88,102.33 108.88,104.31 109.14,104.57 116.13,104.57 117.22,105.67 121.83,105.67 121.83,105.67 121.98,105.67 123.07,106.76 124.1,106.76 124.38,107.04 v1(124.74,107.04)
  L5 w0.089: v1(158.6,103.53) 157.95,103.53 157.06,104.42 157.06,105.8 156,106.86 155.36,106.86 153.95,108.26 153.95,108.46 153.26,109.15 152.07,109.15 151.85,108.92 136.64,108.92 119.75,125.81 119.08,125.81 116.87,123.6 116.87,116.25 119,114.12 120.88,114.12 124.72,110.28 124.72,109.12 125.27,108.58 125.27,107.57 v1(124.74,107.04)
  BOTTOM w0.089: v1(158.6,103.53) 157.58,103.53 R5556.1 156.85,102.8 155.95,102.8 155.42,103.33 155.42,104.16 156.24,104.99 U5503.3 ; v1(108.33,101.45) 108.07,101.19 CPU1.CE9
CAP_LED: length 34.1
  TOP w0.508: v1(75.87,33.71) 75.87,34.04 AFTP6541.1
  L3 w0.508: v1(101.83,30.24) 101.83,29.98 101.37,29.52 97.18,29.52 96.78,29.92 78.62,29.92 75.87,32.67 v1(75.87,33.71)
  BOTTOM w0.229: KB1.4 75.12,34.92 75.44,34.6
  BOTTOM w0.305: R6513.2 100.51,32.03 101.83,30.71 v1(101.83,30.24)
  BOTTOM w0.508: 75.44,34.6 75.44,34.52 75.87,34.09 v1(75.87,33.71)
CAP_LED#: length 6.6
  TOP w0.203: 39.76,71.29 U2401.93
  TOP w0.254: 39.76,71.29 40.54,70.51 R2489.1 41.07,70.14 41.23,69.98 42.63,69.98 v2(43.2,70.55) 43.77,71.13 Q2414.S
CAP_LED#_R: length 105.4
  TOP w0.254: v1(45.37,67.08) 45.37,67.26 45.41,67.31 45.41,68.67 45.37,68.71 Q2414.D ; v1(100,43.56) v2(99.44,43.56)
  L5 w0.254: v1(100,43.56) 99.63,43.19 59.7,43.19 59.33,43.56 32.43,43.56 31.66,44.33 31.66,45.17 30.77,46.06 30.77,47.59 30.41,47.95 30.41,50.96 31.78,52.33 32.31,52.33 34.9,54.92 34.9,57 39.58,61.67 39.58,62.64 41.44,64.5 42.83,64.5 45.37,67.05 v1(45.37,67.08)
  BOTTOM w0.254: v1(100,43.56) 99.43,42.99 Q6505.B
CAP_LED_Q: length 6.9
  BOTTOM w0.305: Q6505.C 100.46,38.51 101.58,37.39 v2(101.58,36.93) 101.58,36.49 101,35.91 100.96,35.91 100.52,35.47 100.52,34.76 C6506.1 100.38,34.75 99.98,34.34 99.98,33.58 100.38,33.17 R6513.1
CARD1_USB20_CON_N: length 6.8
  BOTTOM w0.114: EL6601.3 204.46,39.41 204.15,39.72 203.24,39.72 202.98,39.98 202.51,39.98 202.06,40.44 201.51,40.44 ED6601.1 201.05,40.44 200.86,40.44 200.69,40.27 200.69,39.62 201.01,39.3 201.17,39.3 201.3,39.17 IOBD1.5
CARD1_USB20_CON_P: length 6.7
  BOTTOM w0.114: EL6601.2 204.51,40.09 204.37,39.95 203.98,39.95 ED6601.6 202.61,40.21 202.15,40.67 200.76,40.67 200.46,40.36 200.46,39.52 200.8,39.18 IOBD1.6
CARD1_USB20_N: length 172.6
  TOP w0.114: v2(205.94,38.78) v1(206.36,38.36)
  L6 w0.076: 108.89,104.65 108.89,104.63 108.87,104.62 108.87,102.59 108.96,102.5 108.96,102.16 108.98,102.14 109.03,102.08 v1(109.25,102.08)
  L6 w0.102: 108.89,104.65 108.89,106.34 110.01,107.46 112.91,107.46 114.21,108.76 116.44,108.76 117.24,107.96 117.24,106.3 117.89,105.65 119.69,105.65 123.14,102.2 123.14,97.85 123.1,97.81 122.91,97.62 122.91,91.52 124.29,90.15 124.29,81.49 124.08,81.29 124.08,73.02 126.2,70.9 126.62,70.9 126.88,70.65 126.88,70.64 127.33,70.18 128.44,70.18 131.14,67.49 158.99,67.49 160.15,66.33 170.37,66.33 170.79,65.91 172.03,65.91 172.22,65.72 175.73,65.72 177.12,64.34 177.12,60.17 181.36,55.92 191.2,55.92 191.76,56.49 195.45,56.49 195.96,55.97 198.72,55.97 200,54.69 204.31,54.69 206.79,52.21 208.92,52.21 209.58,51.56 209.58,49.66 209.16,49.24 209.16,46.5 211.08,44.58 211.08,42.57 210.42,41.91 210.42,39.65 209.86,39.09 207.44,39.09 207.29,38.94 206.3,38.94 206.17,38.82 206.17,38.55 v1(206.36,38.36)
  BOTTOM w0.114: CPU1.CG8 108.79,102.09 108.92,102.22 109.12,102.22 v1(109.25,102.08) ; v1(206.36,38.36) 206.36,38.73 206.44,38.81 206.64,38.81 206.77,38.93 206.77,39.24 206.37,39.64 206.19,39.64 EL6601.4
CARD1_USB20_P: length 172.8
  TOP w0.114: v2(207.27,38.89) 207.27,38.63 v1(207,38.36)
  L6 w0.076: v1(109.25,101.43) 108.93,101.8 108.84,101.91 108.78,102.08 108.78,102.43 108.7,102.51 108.7,104.62 108.68,104.63 108.68,104.65
  L6 w0.102: v1(207,38.36) 207.53,38.89 209.94,38.89 210.62,39.57 210.62,41.83 211.28,42.49 211.28,44.66 209.36,46.58 209.36,49.15 209.78,49.57 209.78,51.64 209.01,52.41 206.87,52.41 204.39,54.9 200.08,54.9 198.8,56.18 196.05,56.18 195.53,56.69 191.68,56.69 191.11,56.13 181.44,56.13 177.32,60.25 177.32,64.42 175.82,65.93 172.31,65.93 172.12,66.12 170.88,66.12 170.46,66.54 160.23,66.54 159.08,67.69 131.22,67.69 128.53,70.38 127.42,70.38 127.08,70.72 127.08,70.73 126.71,71.1 126.29,71.1 124.29,73.1 124.29,81.21 124.49,81.41 124.49,90.23 123.12,91.6 123.12,97.54 123.35,97.77 123.35,102.28 119.78,105.85 117.98,105.85 117.44,106.38 117.44,108.05 116.52,108.97 114.13,108.97 112.82,107.66 109.92,107.66 108.68,106.42 108.68,104.65
  BOTTOM w0.114: v1(109.25,101.43) CPU1.CG9 ; EL6601.1 206.52,39.82 207,39.34 v1(207,38.36)
CATERR#_CPU: length 5
  BOTTOM w0.076: CPU1.AA4 81.1,104.81 81.1,105.34 81.24,105.66 81.24,105.66 81.24,106.01 81.22,106.05 81.22,106.27 81.24,106.31 81.24,106.79 81.06,106.97 81.06,107.44
  BOTTOM w0.089: TP301.1 81.03,109.15 81.03,107.69 81.06,107.62 81.06,107.44
CBN: length 8.2
  TOP w0.203: v1(29.09,9.46) 29.06,9.49 29.06,9.75 27.93,10.89 HDA27.28
  TOP w0.254: v2(32.31,6.01) 32.79,6.49 32.79,7.04 C2708.1 32.24,7.6 v1(31.83,7.6)
  L3 w0.254: v1(31.83,7.6) 31.45,7.6 29.58,9.46 v1(29.09,9.46)
CBP: length 5.5
  TOP w0.203: v2(29.59,10.74) 29.49,10.85 29.16,10.85 HDA27.30
  TOP w0.254: v2(29.59,10.74) 29.77,10.57 30.81,10.57 31.74,9.64 32.1,9.64 32.72,9.02 C2708.2
CCD_USB20_CON_N: length 12.1
  TOP w0.114: v2(212.32,48.59) 212.31,48.6 v1(211.76,48.6) 211.76,48.93 212.28,49.44 EL5501.2
  BOTTOM w0.114: LCD1.20 218.44,47.55 218.29,47.7 217.93,47.7 217.35,48.29 216.39,48.29 216.11,48.57 216.11,49.13 215.87,49.37 215.66,49.37 ED5502.1 215.4,49.54 214.81,50.13 214.31,50.13 213.85,49.66 213.85,49.06 213.85,48.98 213.51,48.64 213.1,48.64 213.1,48.65 212.47,48.65 212.24,48.88 212.04,48.88 v1(211.76,48.6)
CCD_USB20_CON_P: length 12.5
  TOP w0.114: EL5501.3 212.15,50.13 212.05,50.03 212.05,49.54 211.59,49.08 v1(211.29,49.08) v2(210.89,49.47)
  BOTTOM w0.114: v1(211.29,49.08) 211.31,49.08 211.34,49.11 ED5502.6 213.04,49.02 213.49,49.02 213.62,49.15 213.62,49.75 214.22,50.36 214.9,50.36 215.66,49.6 215.96,49.6 216.33,49.23 216.33,48.67 216.49,48.52 217.44,48.52 218.03,47.93 218.24,47.93 218.36,48.05 LCD1.19
CCD_USB20_N: length 180.9
  TOP w0.114: EL5501.1 213.96,49.44 v1(214.43,48.97)
  L5 w0.102: v1(109.56,113.48) 109.2,113.48 109.07,113.35 109.07,113.17 108.94,113.05 108.73,113.05 108.49,112.8 108.49,109.97 107.88,109.36 107.88,108.32 109.14,107.06 109.14,106.84 110.44,105.54 112.02,105.54 113.35,104.21 116.4,104.21 116.68,103.94 119.35,103.94 121.69,101.59 121.69,99.98 122.02,99.65 122.02,95.95 125.02,92.96 125.02,73.46 131.49,66.99 132,66.99 132,66.99 159.66,66.99 159.85,66.8 170.64,66.8 172.19,65.25 175.18,65.25 176.89,63.54 176.89,61.49 178.2,60.17 179.17,60.17 182.07,57.28 190.38,57.28 192.01,58.9 207.99,58.9 209.46,60.38 216.15,60.38 218.44,58.09 219.96,58.09 220.4,57.65 220.4,55.45 220.02,55.07 218.98,55.07 218.04,54.13 218.04,53.45 214.93,50.34 214.25,50.34 213.74,49.84 213.74,49.42 213.95,49.22 214.07,49.22 214.21,49.21 v1(214.43,48.97)
  BOTTOM w0.076: 106.9,108.65 106.88,108.63 106.88,108.6 106.6,108.32 106.65,106.76 106.54,106.66 CPU1.CC1
  BOTTOM w0.114: v2(108.89,113.61) 108.89,113.48 ; 108.89,113.48 v1(109.56,113.48) ; 108.89,113.48 108.58,113.48 108.32,113.22 108.32,110.07 107.74,109.49 106.9,108.65
CCD_USB20_P: length 180.9
  TOP w0.114: EL5501.4 213.96,50.13 v1(214.46,49.63) 214.82,50 v2(214.82,50.05)
  L5 w0.102: v1(109.56,112.84) 108.82,112.84 108.69,112.72 108.69,109.88 108.08,109.27 108.08,108.41 109.35,107.14 109.35,106.92 110.53,105.74 112.11,105.74 113.43,104.42 116.49,104.42 116.76,104.14 119.43,104.14 121.9,101.68 121.9,100.06 122.23,99.73 122.23,96.04 125.23,93.04 125.23,73.55 131.58,67.19 131.91,67.19 159.74,67.19 159.93,67.01 170.72,67.01 172.27,65.46 175.26,65.46 177.09,63.63 177.09,61.57 178.29,60.38 179.26,60.38 182.15,57.48 190.3,57.48 191.93,59.11 207.9,59.11 209.38,60.58 216.23,60.58 218.52,58.29 220.04,58.29 220.6,57.74 220.6,55.37 220.1,54.87 219.06,54.87 218.24,54.05 218.24,53.37 215.01,50.14 214.34,50.14 213.95,49.75 213.95,49.51 214.03,49.42 214.07,49.42 214.21,49.41 214.22,49.41 v1(214.46,49.63)
  BOTTOM w0.076: CPU1.CC2 106.7,106.22 106.83,106.34 106.83,106.69 106.83,106.77 106.78,108.25 107.01,108.47 107.04,108.47 107.06,108.48
  BOTTOM w0.114: v1(109.56,112.84) 109.16,113.25 108.68,113.25 108.55,113.12 108.55,109.98 107.06,108.48
CCG4_FLIP#: length 27.6
  TOP w0.089: R7128.1 36.39,120.7 v1(37.04,120.7) 37.51,120.23 v2(37.51,119.76) ; R7127.1 32.95,121.92 v1(32.52,121.49) ; U7201.24 42.17,108.43 v1(42.36,108.63)
  L5 w0.089: v1(37.04,120.7) 37.47,120.27 37.98,120.27 39.33,121.62 40.62,121.62 41.01,121.24 41.32,121.24 43.56,118.99 43.56,116.69 43.13,116.26 43.13,116.24 42.67,115.78 42.65,115.78 42.4,115.53 42.4,115.35 42.39,115.34 42.39,114.07 42.06,113.74 42.06,108.93 v1(42.36,108.63)
  BOTTOM w0.089: v1(32.52,121.49) 33.3,120.7 v1(37.04,120.7)
CCG4_I2C_INT#: length 68.2
  TOP w0.089: v2(22.61,58.9) 22.61,59.62 23.09,60.09 U2401.32 24.61,60.09 25.28,60.76 25.28,60.98 26.04,61.75 26.04,63.88 28.94,66.78 v1(29.37,66.78) ; U7201.8 41.33,112.94 41.43,113.04 41.43,113.31 R7215.2 v1(42.55,113.16)
  L5 w0.089: v1(42.55,113.16) 42.55,110.85 42.79,110.6 42.79,107.82 42.52,107.54 42,107.54 40.8,106.35 40.8,77.05 37.24,73.49 37.24,72.37 36.29,71.43 35.39,71.43 33.66,69.7 32.71,69.7 31.75,68.74 31.75,68.4 30.6,67.24 29.83,67.24 v1(29.37,66.78)
CCG4_I2C_SCL: length 10.1
  TOP w0.114: Q2417.6 33.14,113.26 33.05,113.17 v1(33.05,113.17) ; v1(38.1,114.27) 38.3,114.47 v2(38.64,114.47) 39.42,114.47 RN7201.3 39.55,113.85 39.84,113.55 39.84,113.25 40.33,112.76 U7201.10
  L6 w0.114: v1(33.05,113.17) 34.23,113.17 35.32,114.27 v1(38.1,114.27)
CCG4_I2C_SDA: length 12.8
  TOP w0.114: Q2417.3 v1(35.05,110.75) ; v1(40.97,113.18) 41,113.21 41,113.73 v2(41.01,113.74) 40.41,114.34 RN7201.4 40.22,113.28 40.83,112.67 U7201.9
  L6 w0.114: v1(40.97,113.18) 40.87,113.29 35.74,113.29 35.05,112.59 v1(35.05,110.75)
CCG4_ID_1: length 6.6
  TOP w0.089: U7201.2 43,109.66 43.33,109.33 44.7,109.33 45.01,109.02 45.01,108.43 44.8,108.22 44.36,108.22 43.92,107.79 R7214.1 43.89,107.62 R7212.2 44.12,106.68 v2(44.88,106.68)
CEXT: length 2.3
  TOP w0.127: U5802.17 53.3,114.8 53.39,114.71 v1(53.39,114.61)
  BOTTOM w0.127: C5863.1 53.44,114.56 v1(53.39,114.61) 52.99,114.61 v2(52.81,114.78)
CFG0_DP_MUX: length 2.9
  TOP w0.089: R5815.2 44.99,114.81 44.99,115.88 v2(45.06,115.95) 45.28,115.95 45.76,116.43 U5802.59
CFG3: length 8.7
  BOTTOM w0.089: R1517.1 73.16,111.08 v2(73.16,109.91) 73.16,109.65 75.03,107.77 76.69,107.77 76.97,107.49 76.97,105.47 CPU1.R3
CFG4: length 9.8
  BOTTOM w0.089: CPU1.J4 73.5,104.77 73.19,105.07 73.19,108.22 71.25,110.16 71.25,110.54 v2(70.62,111.18) 70.36,111.43 R1518.1
CFG_RCOMP: length 13.6
  L6 w0.508: v1(81.54,103.56) 81.54,104.55 82.45,105.46 82.45,106.67 83.65,107.88 86.72,107.88 87.57,107.02 v1(87.8,107.02)
  BOTTOM w0.305: v1(81.54,103.56) 81.33,103.55 CPU1.AB5
  BOTTOM w0.508: v1(87.8,107.02) 88.27,107.49 v2(88.27,109.15) 88.84,109.72 R601.1
CHG_AMBER_LED#: length 10.6
  BOTTOM w0.089: Q6406.1 26.61,78.78 26.09,79.3 24.03,79.3 R6408.1 23.19,78.46 R2452.2 22.77,77.63 22.77,76.89 22.18,76.3 v2(22.14,76.3) 21.93,76.09 21.93,74.07 22.37,73.64 22.58,73.64 Q2416.3
CHG_AMBER_LED#_Q: length 134
  TOP w0.089: v1(51.56,74.77) 51.27,74.77 50.5,75.54 46.94,75.54 45.9,76.58 R6405.2 45.27,78.54 44.58,78.54 44.08,78.03 Q6407.2
  L3 w0.089: v1(14.99,110.31) 15.47,110.8 16.34,110.8 17,110.14 20.02,110.14 20.65,109.5 25.99,109.5 26.55,108.94 26.55,102.52 27.23,101.83 27.23,97.39 28,96.62 v1(28,93.8) 30.29,91.51 38.54,91.51 38.72,91.33 38.72,77.85 37.06,76.19 35.55,76.19 34.8,75.44 34.8,74.98 34.07,74.25 31.24,74.25 30.09,75.4 28.55,75.4 27.87,74.72 27.08,74.72 26.83,74.47 25.66,74.47 v1(24.79,75.34)
  L5 w0.089: v1(23.83,77.01) 23.83,76.98 24.79,76.01 v1(24.79,75.34)
  BOTTOM w0.089: v1(14.99,110.31) 14.51,110.31 13.69,109.5 12.75,109.5 12.3,109.96 12.3,110.78 Q6403.B ; v1(28,93.8) 28.53,93.28 38.47,93.28 v2(39.36,92.39) 39.93,91.82 52.05,91.82 53.91,89.97 53.91,88.32 53.29,87.7 53.29,76.5 v1(51.56,74.77) ; v1(23.83,77.01) 23.83,77.09 24.34,77.6 24.34,78.74 R6408.2 24.4,78.78 Q6406.6
CHGR_PSYS_IMVP: length 224.9
  TOP w0.089: PR4442.2 195.58,46.69 v1(195.3,46.41)
  L3 w0.089: v1(169.17,78.97) 170.67,78.97 175.46,74.19 175.46,73.9 176.56,72.79 176.56,70.95 177.87,69.64 179.2,69.64 181.63,67.22 181.63,64.09 184.62,61.09 197.79,61.09 199,62.31 207.74,62.31 208.33,61.71 210.4,61.71 213.03,59.08 213.03,58.99 213.03,58.99 v1(213.03,58.4)
  L5 w0.089: v1(195.3,46.41) 198.39,49.5 198.39,50.54 201.6,53.75 204.73,53.75 207.55,56.57 208.23,56.57 210.05,58.4 v1(213.03,58.4)
  L6 w0.089: v1(169.17,78.97) 167.95,78.97 165.85,81.07 165.85,82.91 164.6,84.16 164.6,89.36 160.74,93.22 160.74,94.5 157.18,98.05 157.18,103.69 157.91,104.42 157.91,106.96 160.65,109.7 161.09,109.7 162.39,111 162.39,111.79 162.06,112.12 160.89,112.12 160.07,112.94 153.1,112.94 152.89,112.73 149.63,112.73 148,114.36 145.21,114.36 138.75,120.82 138.75,123.54 138.01,124.28 138.01,124.95 137.69,125.27 137.69,125.7 137.03,126.35 136.29,126.35 134.89,127.75 134.89,129.44 133.2,131.13 133.2,131.46 133.28,131.54 133.28,133.64 130.61,136.3 129.26,136.3 129.03,136.54 129.03,136.74 128.1,137.67 123.96,137.67 123.77,137.48 119.85,137.48 115.96,141.37 113.66,141.37 113.66,141.37 113.02,141.37 112.74,141.37 110.9,143.21 109.06,143.21 108.96,143.32 108.79,143.48 108.79,145.06 107.6,146.25 107.01,146.25 104.11,149.15 100.74,149.15 95.76,154.12 v1(95.74,154.12)
  BOTTOM w0.089: PR4671.2 85.53,151.46 90.89,151.46 91.21,151.13 92.81,151.13 94.24,152.55 94.24,153.21 v2(95.15,154.12) v1(95.74,154.12)
CLK_ITE8010: length 3.4
  TOP w0.114: R2460.1 215.27,52.88 v2(216.1,52.05) WWAN1.14
CLK_PCIE_LAN_REQ#: length 99
  TOP w0.089: v1(45.93,79) 45.7,79 45.47,79.22 45.47,80.04 45.89,80.46 U3101.12 ; v1(59.19,70.05) 60.4,68.85 102.76,68.85 107.31,73.4 107.31,80.79 108.92,82.4 108.92,86.48 109.48,87.04 109.48,88.07 v1(109,88.55)
  L5 w0.089: v1(43.46,69.6) 43.46,71.03 45.44,73.01 45.44,78.51 v1(45.93,79)
  BOTTOM w0.089: v1(43.46,69.6) 45.32,69.6 46.25,68.66 57.8,68.66 v1(59.19,70.05) ; R1826.2 v1(45.93,79) v2(46.15,78.43) ; v1(109,88.55) 108.99,88.55 CPU1.CF30
CLK_PCIE_NVME_REQ#: length 147.4
  TOP w0.089: v1(23.28,26.84) 23.28,27.66 25.65,30.03 25.65,34.64 27.84,36.83 27.84,38.26 32.69,43.11 v2(33.02,43.11) 33.25,42.88 R1822.2 34.52,43.33 34.52,43.9 35.64,45.02 35.64,46.53 36.45,47.34 38.49,47.34 39.04,46.79 39.95,46.79 40.88,47.72 40.88,49.56 41.57,50.24 44.04,50.24 45.85,52.05 45.9,52.05 53.88,60.02 101.12,60.02 101.41,60.31 106.73,60.31 115.65,69.23 115.65,70.97 117.5,72.82 117.5,77.57 118.62,78.69 v1(118.62,79.12)
  L3 w0.089: v1(108.12,87.86) 107.68,87.42 107.68,86.2 108.5,85.38 114.42,85.38 117.81,81.99 117.81,79.94 v1(118.62,79.12)
  BOTTOM w0.089: v1(108.12,87.86) 107.94,87.86 CPU1.CE30 ; v1(23.28,26.84) 23.7,26.42 SSD1.52
CLK_PCIE_PEG_REQ#: length 51.6
  TOP w0.089: v1(130.09,99.01) 129.29,98.21 129.29,98.21 128.73,97.65 128.73,94.4 129.03,94.11 129.03,86.52 128.48,85.97 128.48,80.23 v2(128.17,79.92) 127.78,79.53 v1(127.52,79.27)
  L3 w0.089: v1(122.95,80.06) 123.38,80.49 123.38,85.01 122.11,86.28 118.36,86.28 117.65,85.57 115.05,85.57 114.64,85.97 110.32,85.97 v1(109.01,87.27)
  BOTTOM w0.089: CPU1.CF32 v1(109.01,87.27) ; v1(122.95,80.06) 123.75,80.06 124.44,80.75 126.8,80.75 127,80.54 127.71,80.54 127.94,80.32 127.94,79.94 127.52,79.51 v1(127.52,79.27) ; R1824.2 129.69,99.01 v1(130.09,99.01) 130.62,99.01 Q7601.D
CLK_PCIE_SD_REQ#: length 90
  TOP w0.089: R1823.2 152.08,69.03 155.07,66.05 155.07,65.19 160.65,59.62 v2(161.15,59.62) v1(162.11,58.66)
  L6 w0.089: v1(162.11,58.66) 161.95,58.81 154.93,58.81 154.67,58.55 128.92,58.55 120.12,67.36 120.12,68.9 109.48,79.54 109.48,84.91 108.64,85.75 108.64,86.92 108.36,87.2 v1(108.11,87.2)
  BOTTOM w0.089: v1(108.11,87.2) 107.95,87.2 CPU1.CE31
CLK_PCIE_WLAN_REQ#: length 222.8
  TOP w0.089: v1(23.68,34.93) 25.61,34.93 27.66,36.98 27.66,38.33 32.81,43.48 33.85,43.48 35.45,45.08 35.45,46.59 36.38,47.52 38.59,47.52 39.14,46.97 39.88,46.97 40.7,47.79 40.7,49.63 41.49,50.42 43.97,50.42 45.77,52.22 45.82,52.22 53.81,60.21 100.95,60.21 101.23,60.49 106.66,60.49 115.47,69.3 115.47,71.05 117.3,72.87 117.3,78 118.19,78.88 118.19,79.33 v1(118.62,79.76) ; v1(43.44,95.68) 43.05,96.07 AFTP6109.1 R1827.2
  L3 w0.089: v1(108.12,86.36) 108.92,85.56 114.49,85.56 118.12,81.93 118.12,80.25 v1(118.62,79.76)
  L6 w0.089: v1(43.44,95.68) 44.15,94.97 44.15,94.34 44.99,93.5 46.08,93.5 48.31,91.26 48.31,86.4 47.37,85.46 47.37,83.3 45.46,81.38 45.16,81.38 44.25,80.47 44.25,74.61 40.33,70.69 39.42,70.69 37.92,69.19 32.28,69.19 30.82,67.73 29.21,67.73 26.2,64.72 26.2,60.63 25.85,60.28 23.62,60.28 20.89,57.54 20.89,53.67 21.72,52.83 21.72,50.99 21.22,50.49 21.22,43.09 21.76,42.55 21.76,37.8 22.91,36.65 22.91,35.69 v1(23.68,34.93)
  BOTTOM w0.089: v1(43.44,95.68) 43.95,96.2 WLAN1.53 ; CPU1.CE32 108.12,86.37 v1(108.12,86.36)
CLK_TP_SIO: length 142.7
  TOP w0.114: v1(100.76,41.35) 100.76,41.42 101.5,42.16 102.93,42.16 103.54,42.77 104.93,42.77 105.4,42.3 105.4,39.72 106.34,38.79 108.49,38.79 110.04,37.24 EC6503.1 110.06,37.12 RN6502.1 110.06,36.05 111,35.1 111,33.45 110.37,32.82 109.78,32.82 v2(109.58,32.61) 108.21,32.61 107.42,31.83 RN6501.3 ; v1(37.04,64.85) 37.48,65.29 U2401.78
  L3 w0.089: v1(100.76,41.35) 100.76,40.35 99.37,38.96 91.31,38.96 90.41,38.06 81.58,38.06 81.14,38.5 76.95,38.5 74.28,35.83 65.09,35.83 64.66,36.27 55.33,36.27 52.63,33.57 37.99,33.57 37.16,34.4 34.13,34.4 33.23,33.5 29.44,33.5 28.78,34.16 28.78,34.9 28.36,35.32 28.36,39.16 28.67,39.47 28.67,40.31 26.71,42.26 26.71,48.83 31.23,53.35 31.23,55.85 36.32,60.95 37.4,60.95 38.32,61.88 38.32,64.92 37.97,65.27 37.46,65.27 v1(37.04,64.85)
CLKIN_XTAL_LCP: length 24.5
  BOTTOM w0.114: R1804.1 122.25,115.37 R1817.1 arc(122.88,115.08) 123.12,114.5 C1809.1 arc(123.05,114.15) 122.87,113.87 122.57,113.58 arc(122.19,113) 122.05,112.32 122.05,111.76 arc(122.2,110.99) 122.64,110.33 arc(123.16,109.55) 123.35,108.64 123.35,107.9 arc(123.18,107.06) 122.7,106.34 121.82,105.46 arc(121.28,105.1) 120.65,104.98 117.61,104.98 arc(117.02,105.09) 116.53,105.42 114.95,107 arc(114.63,107.22) 114.25,107.29 113.29,107.29 arc(112.85,107.2) 112.47,106.95 112.21,106.69 arc(112.15,106.61) 112.13,106.51 arc(112.11,106.4) 112.05,106.31 111.97,106.22 111.89,106.15 arc(111.69,105.85) CPU1.CM3
CMP_VIN0: length 4.1
  TOP w0.114: R2470.2 20.32,64.52 20.37,64.57 20.55,64.74 21.45,64.74 21.62,64.57 v2(21.75,64.57) 22.19,64.57 22.2,64.56 22.56,64.56 22.57,64.57 22.71,64.57 23.04,64.89 U2401.20
CMP_VIN0_R: length 37.4
  TOP w0.114: v1(19.64,65.15) 19.63,65.15 19.1,64.63 R2470.1
  L3 w0.102: v1(35.05,77.78) 34.68,77.78 34.06,77.16 32.87,77.16 32.15,76.45 26.54,76.45 26.4,76.59 24.57,76.59 24.46,76.48 23.22,76.48 21.19,74.45 21.19,74.41 21.18,74.4 21.18,72.87 19.64,71.32 v1(19.64,65.15)
  BOTTOM w0.114: C2612.1 C2613.1 17.79,63.6 18.71,64.52 R2608.2 19.18,64.7 v1(19.64,65.15) ; v1(35.05,77.78) 35.54,77.29 36.93,77.29 37.53,77.9 39.6,77.9 v2(40.36,78.67) 40.36,79.48 R2610.1
CMP_VOUT0: length 233.6
  TOP w0.114: U2401.85 39.7,68.09 40.21,68.61 40.21,68.71 v1(40.47,68.96) 40.72,69.22 R2607.2 ; v1(27.51,23.17) 27.47,23.2 27.47,27.43 30.61,30.57 30.66,30.57 31.27,31.18 v1(31.27,34.16) ; v1(129.77,106.76) v2(129.77,106.12) 129.77,105.72 130.45,105.04 130.45,101.98 129.64,101.16 129.64,100.38 129.91,100.1 130.24,100.1 130.53,99.82 130.53,98.83 130.27,98.57 130.12,98.57 129.06,97.51 129.06,94.54 129.36,94.24 129.36,86.38 128.81,85.83 128.81,79.05 126.76,77 126.76,73.69 127.2,73.25 127.2,70.15 111.23,54.18 57.52,54.18 53.24,49.9 53.24,43.29 53.24,43.28 53.24,43.01 53.83,42.43 53.83,41.62 53.83,41.2 52.95,40.32 52.95,36.56 53.64,35.87 53.64,34.27 53.17,33.8 50.7,31.33 50.43,31.33 50.28,31.33 50.28,31.33 39.44,31.33 35.56,27.45 35.56,25.67 v1(33.25,23.36)
  L3 w0.089: v1(31.27,34.16) 31.7,34.6 31.7,40.06 30.86,40.9 29.26,40.9 27.56,42.59 27.56,48.46 32.06,52.95 32.06,54.35 36.36,58.65 39.64,58.65 40.21,59.22 40.21,68.71 v1(40.47,68.96)
  BOTTOM w0.114: v1(27.51,23.17) 28.21,23.86 32.75,23.86 v1(33.25,23.36) ; R2615.2 130.28,107.27 v1(129.77,106.76) 129.57,106.76 129.29,106.48 129.12,106.48 R2602.2
CNV_BRI_DT: length 26.5
  TOP w0.114: v2(109.48,93.78) 109.59,93.89 v1(110.09,93.89) ; v1(111.59,80.52) 109.2,78.13 109.2,77.35 109.08,77.23 108.99,77.23 108.88,77.12 108.88,76.89 108.99,76.77 109.08,76.77 109.2,76.66 R2058.2
  L6 w0.114: v1(110.09,93.89) 110.25,93.73 111.76,93.73 111.98,93.5 114.48,93.5 115.01,92.97 115.01,90.93 112.53,88.45 112.53,84.35 112.71,84.17 112.71,81.64 v1(111.59,80.52)
  BOTTOM w0.114: v1(110.09,93.89) 110.09,94.13 CPU1.CJ20
CNV_BRI_DT_R: length 113.5
  TOP w0.114: v1(38.69,102.62) 39.17,102.62 v2(39.37,102.41) 40.19,101.6 40.19,101.03 41.36,99.86 53.51,99.86 54.18,99.19 54.18,92.09 58.2,88.08 59.93,88.08 62.41,85.6 62.41,82.62 60.62,80.83 60.02,80.83 58.23,79.03 58.23,72.54 57.46,71.78 57.46,69.58 59.5,67.54 103.3,67.54 109.2,73.44 R2058.1
  BOTTOM w0.114: v1(38.69,102.62) 39.2,102.62 39.7,103.12 WLAN1.36
CNV_BRI_RSP: length 138.8
  TOP w0.114: RN2001.3 114.9,94.69 113.89,94.69 113.53,94.33 110.78,94.33 110.52,94.59 v1(110.52,94.87) ; v1(111.61,79.22) 110.15,77.77 110.15,73.39 v2(109.78,73.03) 103.61,66.85 59.22,66.85 56.78,69.3 56.78,72.06 57.54,72.82 57.54,80.36 55.3,82.6 55.3,90.01 53.5,91.81 53.5,98.91 53.23,99.18 40.22,99.18 R6123.1
  L6 w0.114: v1(111.61,79.22) 113.29,80.91 113.29,87.4 115.77,89.88 115.77,91.72 115.88,91.84 116.37,91.84 116.49,91.95 116.49,92.18 116.37,92.29 115.88,92.29 115.77,92.41 115.77,92.64 115.88,92.75 115.97,92.75 116.08,92.86 116.08,93.09 115.97,93.21 115.88,93.21 115.77,93.32 115.77,94.03 115.01,94.79 112.36,94.79 111.81,95.33 111.03,95.33 110.88,95.19 110.84,95.19 v1(110.52,94.87)
  BOTTOM w0.114: v1(110.52,94.87) 110.96,94.43 CPU1.CK20
CNV_BRI_RSP_R: length 7.2
  TOP w0.114: R6123.2 38.36,101.04 v2(37.16,101.04) 35.94,102.27 35.94,103.07 v1(36.38,103.51)
  BOTTOM w0.114: WLAN1.22 36.2,103.68 v1(36.38,103.51)
CNV_MFUART2_RXD: length 1.3
  TOP w0.114: v1(110.04,95.95) 110.32,95.67 TP2102.1
  BOTTOM w0.114: v1(110.04,95.95) 110.13,95.95 110.31,96.12 CPU1.CJ17
CNV_MFUART2_TXD: length 1.4
  TOP w0.114: TP2103.1 109.25,95.84 v1(109.38,95.84)
  BOTTOM w0.114: CPU1.CH17 109.66,96.12 v1(109.38,95.84)
CNV_PA_BLANKING: length 6.7
  BOTTOM w0.114: TP2101.1 116.86,92.89 116.05,93.7 116.05,94.39 115.65,94.79 113.18,94.79 CPU1.CP20
CNV_RGI_DT: length 27.7
  TOP w0.114: v1(111.59,81.18) 108.44,78.03 v2(108.44,76.92) R2057.2
  L6 w0.114: v1(111.59,81.18) 111.05,81.71 111.05,83.31 112.06,84.32 112.06,88.39 114.72,91.05 114.72,92.84 114.35,93.21 111.7,93.21 111.52,93.38 109.82,93.38 109.04,94.16 109.04,94.43 v1(108.59,94.88)
  BOTTOM w0.114: CPU1.CG19 108.59,94.97 v1(108.59,94.88)
CNV_RGI_DT_R: length 113.6
  TOP w0.114: R1515.2 37.78,103.04 R1516.1 38.4,103.24 v1(38.7,103.54) 39.03,103.54 40.53,102.04 40.53,101.17 41.5,100.2 53.66,100.2 54.52,99.34 54.52,92.24 58.34,88.42 60.08,88.42 62.75,85.75 62.75,82.48 60.76,80.49 60.17,80.49 58.57,78.89 58.57,72.4 57.81,71.63 57.81,69.72 59.65,67.88 103.16,67.88 108.44,73.16 v2(108.44,73.91) R2057.1
  BOTTOM w0.114: WLAN1.32 v1(38.7,103.54)
CNV_RGI_RSP: length 139.7
  TOP w0.114: R6120.1 40.47,100.13 v2(41.05,99.54) 41.07,99.52 53.37,99.52 53.84,99.05 53.84,91.95 55.64,90.15 55.64,82.74 57.88,80.5 57.88,72.68 57.12,71.92 57.12,69.44 59.36,67.2 103.44,67.2 109.81,73.56 109.81,78.11 v1(111.59,79.88) ; v1(109.22,94.88) 109.81,94.3 110.33,94.3 110.54,94.08 113.59,94.08 113.98,94.47 114.4,94.47 114.7,94.16 115.5,94.16 115.6,94.27 RN2001.4
  L6 w0.114: v1(111.59,79.88) 113,81.3 113,88.36 114.18,89.54 115.01,89.54 115.48,90 115.48,93.91 114.89,94.5 110.73,94.5 110.69,94.46 109.65,94.46 v1(109.22,94.88)
  BOTTOM w0.114: v1(109.22,94.88) 109.22,94.95 CPU1.CH19
CNV_RGI_RSP_R: length 9.3
  TOP w0.114: v1(36.38,102.82) 36.38,102.36 37.34,101.4 v2(38.66,101.4) 39.09,101.4 R6120.2
  BOTTOM w0.114: v1(36.38,102.82) 36.66,103.1 38.92,103.1 39.2,103.38 WLAN1.34
CNV_WR_CLK_DN: length 143
  TOP w0.114: v1(35.44,95.73) 35.33,95.63 34.87,95.63 34.57,95.33 34.57,94.17 34.99,93.75 43.39,93.75 43.56,93.58 43.56,92.69 43.92,92.33 48.42,92.33 52.5,88.25 52.5,81.44 54.75,79.2 54.75,74.19 53.98,73.43 53.98,68.14 58.06,64.06 74.17,64.06 74.29,63.95 74.29,63.58 74.53,63.34 75.12,63.34 75.37,63.58 75.37,63.95 75.48,64.06 75.87,64.06 75.99,63.95 75.99,63.58 76.24,63.34 76.82,63.34 77.07,63.58 77.07,63.95 77.18,64.06 77.58,64.06 77.69,63.95 77.69,63.58 77.94,63.34 78.52,63.34 78.77,63.58 78.77,63.95 78.88,64.06 79.28,64.06 79.39,63.95 79.39,63.58 79.64,63.34 80.3,63.34 80.55,63.58 80.55,63.95 80.66,64.06 81.05,64.06 81.17,63.95 81.17,63.58 81.42,63.34 82,63.34 82.25,63.58 82.25,63.95 82.36,64.06 82.76,64.06 82.87,63.95 82.87,63.58 83.12,63.34 83.7,63.34 83.95,63.58 83.95,63.95 84.06,64.06 84.46,64.06 84.57,63.95 84.57,63.58 84.82,63.34 85.48,63.34 85.73,63.58 85.73,63.95 85.84,64.06 86.24,64.06 86.35,63.95 86.35,63.58 86.6,63.34 87.18,63.34 87.43,63.58 87.43,63.95 87.54,64.06 87.94,64.06 88.05,63.95 88.05,63.58 88.3,63.34 88.88,63.34 89.13,63.58 89.13,63.95 89.25,64.06 89.64,64.06 89.75,63.95 89.75,63.58 90,63.34 90.59,63.34 90.83,63.58 90.83,63.95 90.95,64.06 91.34,64.06 91.46,63.95 91.46,63.58 91.7,63.34 104.19,63.34 114.72,73.87 114.72,76.78 114.85,76.91 v1(115.2,76.91)
  BOTTOM w0.076: 115.51,87.03 115.46,87.03 115.43,87.07 115.42,87.07 114.75,87.74 113.73,87.74 113.65,87.82 113.28,87.82 113.03,87.57 CPU1.CN31
  BOTTOM w0.114: v1(35.44,95.73) 35.69,95.98 35.69,95.98 35.95,96.24 WLAN1.21 ; 115.51,87.03 115.7,86.84 115.7,86.41 116.57,85.54 116.57,82.02 117.35,81.23 117.35,78.15 116.09,76.89 115.22,76.89 v1(115.2,76.91)
CNV_WR_CLK_DP: length 143
  TOP w0.114: v1(35.44,95.1) 35.14,95.4 34.96,95.4 34.8,95.24 34.8,94.26 35.08,93.98 43.49,93.98 43.79,93.68 43.79,92.78 44.02,92.56 48.52,92.56 52.73,88.34 52.73,81.54 54.97,79.3 54.97,74.09 54.21,73.33 54.21,68.23 58.16,64.29 74.27,64.29 74.51,64.04 74.51,63.68 74.63,63.56 75.02,63.56 75.14,63.68 75.14,64.04 75.38,64.29 75.97,64.29 76.22,64.04 76.22,63.68 76.33,63.56 76.72,63.56 76.84,63.68 76.84,64.04 77.09,64.29 77.67,64.29 77.92,64.04 77.92,63.68 78.03,63.56 78.43,63.56 78.54,63.68 78.54,64.04 78.79,64.29 79.37,64.29 79.62,64.04 79.62,63.68 79.73,63.56 80.2,63.56 80.32,63.68 80.32,64.04 80.57,64.29 81.15,64.29 81.4,64.04 81.4,63.68 81.51,63.56 81.91,63.56 82.02,63.68 82.02,64.04 82.27,64.29 82.85,64.29 83.1,64.04 83.1,63.68 83.21,63.56 83.61,63.56 83.72,63.68 83.72,64.04 83.97,64.29 84.55,64.29 84.8,64.04 84.8,63.68 84.92,63.56 85.39,63.56 85.5,63.68 85.5,64.04 85.75,64.29 86.33,64.29 86.58,64.04 86.58,63.68 86.69,63.56 87.09,63.56 87.2,63.68 87.2,64.04 87.45,64.29 88.03,64.29 88.28,64.04 88.28,63.68 88.4,63.56 88.79,63.56 88.9,63.68 88.9,64.04 89.15,64.29 89.73,64.29 89.98,64.04 89.98,63.68 90.1,63.56 90.49,63.56 90.61,63.68 90.61,64.04 90.85,64.29 91.44,64.29 91.68,64.04 91.68,63.68 91.8,63.56 104.09,63.56 114.49,73.97 114.49,76.87 114.71,77.09 114.71,77.57 114.84,77.7 115.04,77.7 v1(115.19,77.55)
  BOTTOM w0.076: 115.35,86.87 115.35,86.89 114.68,87.57 CPU1.CP31
  BOTTOM w0.114: WLAN1.23 36.45,96.82 36.18,96.55 36.18,96.15 35.92,95.89 35.92,95.53 35.97,95.48 35.97,95.12 35.84,95 35.54,95 v1(35.44,95.1) ; 115.35,86.87 115.47,86.75 115.47,86.31 116.34,85.44 116.34,81.92 117.12,81.14 117.12,78.25 115.99,77.12 115.78,77.12 115.65,77.24 115.65,77.54 115.52,77.67 115.32,77.67 v1(115.19,77.55)
CNV_WR_DN0: length 143
  TOP w0.114: v1(116.18,87.97) 116.35,87.8 116.69,87.8 116.97,87.53 116.97,86.57 115.78,85.38 115.78,82.42 116.82,81.38 116.82,79.44 115.88,78.5 115.88,74.04 104.45,62.61 71.92,62.61 71.68,62.86 71.68,63.25 71.56,63.36 71.17,63.36 71.05,63.25 71.05,62.86 70.81,62.61 70.22,62.61 69.97,62.86 69.97,63.25 69.86,63.36 69.47,63.36 69.35,63.25 69.35,62.86 69.1,62.61 68.52,62.61 68.27,62.86 68.27,63.25 68.16,63.36 67.76,63.36 67.65,63.25 67.65,62.86 67.4,62.61 66.82,62.61 66.57,62.86 66.57,63.25 66.46,63.36 66.06,63.36 65.95,63.25 65.95,62.86 65.7,62.61 65.12,62.61 64.87,62.86 64.87,63.25 64.75,63.36 64.36,63.36 64.25,63.25 64.25,62.86 64,62.61 63.42,62.61 63.17,62.86 63.17,63.25 63.05,63.36 62.66,63.36 62.54,63.25 62.54,62.86 62.3,62.61 61.71,62.61 61.47,62.86 61.47,63.25 61.35,63.36 60.96,63.36 60.84,63.25 60.84,62.86 60.6,62.61 58.44,62.61 53.29,67.76 53.29,73.81 54.05,74.57 54.05,78.91 51.81,81.15 51.81,87.96 48.13,91.63 42.43,91.63 41.04,93.03 33.6,93.03 33.11,93.53 33.11,95.28 33.35,95.53 33.74,95.53 v1(33.94,95.73)
  BOTTOM w0.076: CPU1.CR30 113.65,88.16 114.94,88.16 115.28,87.82 116.03,87.82 v1(116.18,87.97)
  BOTTOM w0.114: WLAN1.15 34.45,97.52 34.45,95.93 34.25,95.73 v1(33.94,95.73)
CNV_WR_DN1: length 143
  TOP w0.114: v1(32.44,95.73) 32.26,95.56 31.97,95.56 31.74,95.33 31.74,93.8 33.21,92.33 40.75,92.33 42.14,90.93 47.84,90.93 51.11,87.67 51.11,80.86 53.35,78.62 53.35,74.93 52.59,74.17 52.59,67.47 58.16,61.9 104.73,61.9 116.64,73.81 116.64,78.23 117.53,79.12 117.53,81.66 116.47,82.72 116.47,85.09 118.62,87.23 118.62,87.99 118.14,88.47 117.57,88.47 v1(117.42,88.62)
  BOTTOM w0.076: 115.21,88.95 115.19,88.95 115.17,88.93 114.91,88.93 114.57,88.58 114.06,88.58 113.96,88.69 113.39,88.69 113.26,88.61 113.25,88.61 113.06,88.61 112.97,88.62 112.69,88.62 112.59,88.52 112.04,88.52 111.74,88.22 CPU1.CM30
  BOTTOM w0.114: 115.21,88.95 116.31,88.95 116.69,88.57 117.37,88.57 v1(117.42,88.62) ; v1(32.44,95.73) 32.8,95.73 32.95,95.88 32.95,96.42 32.95,96.42 WLAN1.9
CNV_WR_DP0: length 143
  TOP w0.114: v1(33.94,95.1) 33.74,95.3 33.45,95.3 33.33,95.19 33.33,93.62 33.7,93.26 41.13,93.26 42.53,91.86 48.23,91.86 52.03,88.05 52.03,81.25 54.28,79.01 54.28,74.47 53.51,73.71 53.51,67.86 58.53,62.84 60.5,62.84 60.61,62.96 60.61,63.34 60.86,63.59 61.45,63.59 61.69,63.34 61.69,62.96 61.81,62.84 62.2,62.84 62.32,62.96 62.32,63.34 62.56,63.59 63.15,63.59 63.4,63.34 63.4,62.96 63.51,62.84 63.9,62.84 64.02,62.96 64.02,63.34 64.27,63.59 64.85,63.59 65.1,63.34 65.1,62.96 65.21,62.84 65.61,62.84 65.72,62.96 65.72,63.34 65.97,63.59 66.55,63.59 66.8,63.34 66.8,62.96 66.91,62.84 67.31,62.84 67.42,62.96 67.42,63.34 67.67,63.59 68.25,63.59 68.5,63.34 68.5,62.96 68.62,62.84 69.01,62.84 69.12,62.96 69.12,63.34 69.37,63.59 69.95,63.59 70.2,63.34 70.2,62.96 70.32,62.84 70.71,62.84 70.83,62.96 70.83,63.34 71.07,63.59 71.66,63.59 71.9,63.34 71.9,62.96 72.02,62.84 104.36,62.84 115.65,74.13 115.65,78.59 116.59,79.53 116.59,81.29 115.55,82.33 115.55,85.47 116.74,86.67 116.74,87.43 116.6,87.58 116.42,87.58 v1(116.18,87.34)
  BOTTOM w0.076: CPU1.CP30 113.11,87.98 114.86,87.98 115.2,87.64 115.88,87.64 v1(116.18,87.34)
  BOTTOM w0.114: v1(33.94,95.1) 34.67,95.83 34.67,96.55 34.95,96.82 WLAN1.17
CNV_WR_DP1: length 143
  TOP w0.114: v1(117.42,87.99) 117.42,87.98 117.57,87.82 117.75,87.82 117.88,87.96 117.88,88.14 117.96,88.22 118.07,88.22 118.39,87.89 118.39,87.33 116.25,85.18 116.25,82.62 117.3,81.57 117.3,79.22 116.41,78.33 116.41,73.91 104.63,62.13 58.26,62.13 52.82,67.57 52.82,74.07 53.58,74.84 53.58,78.72 51.34,80.96 51.34,87.76 47.94,91.16 42.24,91.16 40.84,92.56 33.3,92.56 31.97,93.89 31.97,95.23 32.07,95.33 32.26,95.33 32.44,95.15 v1(32.44,95.1)
  BOTTOM w0.076: 115.21,88.72 115.19,88.72 115.17,88.75 114.99,88.75 114.64,88.41 113.99,88.41 113.88,88.51 113.44,88.51 113.37,88.47 113.36,88.47 113.33,88.43 113.05,88.43 112.97,88.44 112.76,88.44 112.5,88.19 112.32,88.19 CPU1.CN30
  BOTTOM w0.114: v1(117.42,87.99) 117.28,87.85 117.1,87.85 116.97,87.97 116.97,88.22 116.84,88.34 116.6,88.34 116.21,88.72 115.21,88.72 ; v1(32.44,95.1) 32.71,94.83 32.95,94.83 33.07,94.96 33.07,95.18 32.93,95.32 32.93,95.54 33.18,95.78 33.18,96.33 33.24,96.39 33.35,96.39 33.45,96.5 WLAN1.11
CNV_WT_CLK_DN: length 120.1
  TOP w0.114: v1(47.96,95.73) 48.08,95.86 48.26,95.86 48.39,95.73 48.39,95.45 48.52,95.33 49.31,95.33 50.07,94.57 50.23,94.57 50.68,95.02 51.06,95.02 51.43,94.65 51.43,94.24 51,93.81 51,93.65 51.27,93.37 51.44,93.37 52.25,94.19 52.63,94.19 53.03,93.79 53.03,93.43 52.2,92.6 52.2,92.44 54.83,89.81 54.83,82.41 57.07,80.17 57.07,73.02 56.31,72.25 56.31,69.1 59.03,66.38 96.55,66.38 97.25,65.69 97.64,65.69 97.76,65.8 97.76,66.14 98,66.38 98.59,66.38 98.84,66.14 98.84,65.8 98.95,65.69 99.34,65.69 99.46,65.8 99.46,66.14 99.71,66.38 100.29,66.38 100.54,66.14 100.54,65.8 100.65,65.69 101.05,65.69 101.16,65.8 101.16,66.14 101.41,66.38 101.99,66.38 102.24,66.14 102.24,65.8 102.35,65.69 103.24,65.69 110.9,73.35 110.9,75.94 111.15,76.19 112.26,76.19 112.37,76.3 112.37,76.69 112.26,76.81 111.15,76.81 110.9,77.06 110.9,77.73 111.15,77.98 111.79,77.98 112.04,78.23 112.04,78.96 112.18,79.1 112.41,79.1 v1(112.59,78.92)
  BOTTOM w0.076: CPU1.CP34 113.18,85.81 113.23,85.83 113.31,85.83 113.33,85.84 113.36,85.85 113.43,85.88 113.46,85.89 113.68,85.89 113.97,85.6 113.97,84.57 113.95,84.55 113.95,84.54
  BOTTOM w0.114: 113.95,84.54 113.95,83.36 113.57,82.98 113.57,78.74 113.39,78.56 113.19,78.56 113.06,78.69 113.06,78.95 112.93,79.08 112.75,79.08 v1(112.59,78.92) ; v1(47.96,95.73) 47.96,95.68 48.13,95.52 48.36,95.52 48.72,95.88 48.72,96.52 48.45,96.79 WLAN1.71
CNV_WT_CLK_DP: length 120.2
  TOP w0.114: v1(47.96,95.1) 49.22,95.1 49.97,94.34 50.33,94.34 50.78,94.79 50.96,94.79 51.2,94.55 51.2,94.34 50.77,93.9 50.77,93.55 51.18,93.14 51.53,93.14 52.35,93.96 52.54,93.96 52.8,93.7 52.8,93.52 51.97,92.7 51.97,92.35 54.6,89.72 54.6,82.31 56.84,80.07 56.84,73.11 56.08,72.35 56.08,69.01 58.93,66.16 96.46,66.16 97.15,65.46 97.74,65.46 97.99,65.71 97.99,66.04 98.1,66.16 98.49,66.16 98.61,66.04 98.61,65.71 98.86,65.46 99.44,65.46 99.69,65.71 99.69,66.04 99.8,66.16 100.2,66.16 100.31,66.04 100.31,65.71 100.56,65.46 101.14,65.46 101.39,65.71 101.39,66.04 101.5,66.16 101.9,66.16 102.01,66.04 102.01,65.71 102.26,65.46 103.34,65.46 111.13,73.25 111.13,75.84 111.24,75.96 112.35,75.96 112.6,76.21 112.6,76.79 112.35,77.04 111.24,77.04 111.13,77.15 111.13,77.63 111.25,77.75 111.88,77.75 112.42,78.28 v1(112.59,78.28)
  BOTTOM w0.076: 114.18,84.54 114.18,84.56 114.15,84.58 114.15,85.67 113.75,86.07 113.43,86.07 113.37,86.05 113.34,86.04 113.32,86.03 113.29,86.01 113.26,86 113,86 112.95,86.06 112.64,86.06 CPU1.CN34
  BOTTOM w0.114: 114.18,84.54 114.18,83.27 113.8,82.89 113.8,78.65 113.48,78.33 112.73,78.33 112.64,78.33 v1(112.59,78.28) ; v1(47.96,95.1) 48.26,95.1 48.95,95.79 WLAN1.73
CNV_WT_DN0: length 120.3
  TOP w0.114: v1(114.45,79.93) 114.66,79.93 114.8,80.07 114.8,80.24 114.54,80.49 114.09,80.49 113.31,79.71 113.31,74.45 103.6,64.73 96.89,64.73 96.17,65.46 58.64,65.46 55.38,68.72 55.38,72.64 56.14,73.4 56.14,79.78 53.9,82.02 53.9,89.43 49.6,93.73 46.06,93.73 45.55,94.24 45.55,94.82 45.9,95.18 45.9,95.66 46.03,95.78 46.36,95.78 v1(46.43,95.71)
  BOTTOM w0.076: 115.09,85.65 115.08,85.67 115.08,85.7 114.81,85.97 114.81,86.82 114.51,87.12 113.67,87.12 113.67,87.13 113.44,87.13 113.44,87.12 113.06,87.12 113.05,87.13 112.76,87.13 112.75,87.12 112.43,87.12 CPU1.CN32
  BOTTOM w0.114: 115.09,85.65 115.62,85.12 115.62,81.56 115.88,81.31 115.88,80.75 115.22,80.09 115.04,80.09 114.72,80.4 114.54,80.4 114.38,80.24 114.38,80 v1(114.45,79.93) ; v1(46.43,95.71) 46.69,95.45 46.89,95.45 47.22,95.78 47.22,96.42 46.95,96.69 WLAN1.65
CNV_WT_DN1: length 120.4
  TOP w0.114: v1(44.99,95.73) 44.76,95.51 44.3,95.51 44,95.2 44,94.39 45.36,93.03 49.31,93.03 53.2,89.14 53.2,81.73 55.44,79.49 55.44,73.81 54.68,73.04 54.68,68.43 58.35,64.76 92.36,64.76 92.47,64.64 92.47,64.28 92.72,64.03 93.3,64.03 93.55,64.28 93.55,64.64 93.66,64.76 94.06,64.76 94.17,64.64 94.17,64.28 94.42,64.03 95,64.03 95.25,64.28 95.25,64.64 95.37,64.76 95.88,64.76 96.6,64.03 103.89,64.03 114.02,74.17 114.02,77.64 115.95,79.57 115.95,81.2 115.26,81.89 v1(114.45,81.89)
  BOTTOM w0.076: CPU1.CP33 113.33,86.3 113.86,86.3 114.4,85.75 114.4,85.37 114.87,84.9 114.87,84.65 114.85,84.63 114.85,84.61
  BOTTOM w0.114: WLAN1.59 45.45,95.86 45.32,95.73 v1(44.99,95.73) ; v1(114.45,81.89) 114.47,81.91 114.71,81.91 114.85,82.05 114.85,84.61
CNV_WT_DP0: length 120.4
  TOP w0.114: v1(114.9,79.48) 114.9,79.85 115.03,79.98 115.03,80.33 114.64,80.72 113.99,80.72 113.08,79.81 113.08,74.54 103.5,64.96 96.98,64.96 96.26,65.69 58.74,65.69 55.61,68.81 55.61,72.54 56.37,73.31 56.37,79.88 54.13,82.12 54.13,89.52 49.7,93.96 46.15,93.96 45.77,94.34 45.77,94.72 46.1,95.05 v1(46.43,95.05)
  BOTTOM w0.076: CPU1.CM32 111.99,87.27 112.35,87.3 112.35,87.3 112.68,87.3 112.68,87.31 113.13,87.31 113.13,87.3 113.36,87.3 113.37,87.31 113.74,87.31 113.75,87.3 114.58,87.3 114.99,86.89 114.99,86.05 115.21,85.83 115.24,85.83 115.26,85.82
  BOTTOM w0.114: WLAN1.67 47.45,95.69 46.99,95.23 46.61,95.23 v1(46.43,95.05) ; v1(114.9,79.48) 114.94,79.48 116.11,80.65 116.11,81.4 115.85,81.66 115.85,85.22 115.26,85.82
CNV_WT_DP1: length 120.3
  TOP w0.114: v1(114.9,81.45) 115.39,81.45 115.73,81.11 115.73,79.67 113.8,77.74 113.8,74.26 103.79,64.26 96.7,64.26 95.97,64.99 95.27,64.99 95.02,64.74 95.02,64.38 94.91,64.26 94.52,64.26 94.4,64.38 94.4,64.74 94.15,64.99 93.57,64.99 93.32,64.74 93.32,64.38 93.21,64.26 92.81,64.26 92.7,64.38 92.7,64.74 92.45,64.99 58.45,64.99 54.91,68.52 54.91,72.95 55.67,73.71 55.67,79.59 53.43,81.83 53.43,89.23 49.41,93.26 45.46,93.26 44.22,94.49 44.22,95.11 44.4,95.28 44.78,95.28 v1(44.99,95.07)
  BOTTOM w0.076: 115.08,84.61 115.08,84.63 115.05,84.65 115.05,84.97 114.58,85.44 114.58,85.83 113.94,86.48 113.53,86.48 113.43,86.58 113.05,86.58 112.91,86.43 CPU1.CN33
  BOTTOM w0.114: v1(114.9,81.45) 114.88,81.45 114.88,81.75 115.08,81.95 115.08,84.61 ; WLAN1.61 45.95,96.77 45.68,96.5 45.68,95.77 45.32,95.4 v1(44.99,95.07)
CNV_WT_RCOMP: length 4.1
  TOP w0.254: R2101.1 113.78,87.91 114.26,87.43 114.26,87.42 v2(114.3,87.39) 114.37,87.31 v1(114.37,86.7)
  BOTTOM w0.114: v1(114.37,86.7) 114.22,86.85 CPU1.CR32 113.53,86.87 CPU1.CP32
CNVI_EN#: length 239
  TOP w0.089: v1(47.55,107.95) 47.76,107.75 R6110.2 ; v1(120.45,89.48) 123.32,86.61 123.32,82.6 117.87,77.15 v2(117.87,69.52) 118.05,69.34 118.05,66.93 108.34,57.21 99.19,57.21 98.93,57.47 55.23,57.47 47.65,49.9 47.65,49.1 47.63,49.08 47.63,44.48 46.28,43.13 46.25,43.13 45.79,42.67 42.23,42.67 41.54,41.97 37.23,41.97 36.6,41.35 36.6,39.38 35.45,38.23 35.45,37.85 33.96,36.36 32.4,36.36 32.18,36.15 v1(32.18,35.74)
  L6 w0.089: v1(47.55,107.95) 47.86,107.65 47.86,105.59 47.25,104.98 47.25,101.09 46.01,99.86 46.01,94.24 48.77,91.48 48.77,86.3 47.78,85.31 47.78,83.35 47.78,83.2 45.98,81.4 45.98,80.39 45.29,79.7 45.29,78.27 45.18,78.17 45.18,75.04 40.48,70.33 39.65,70.33 38.15,68.84 32.43,68.84 30.8,67.2 29.19,67.2 26.58,64.6 26.58,60.5 25.21,59.13 24.11,59.13 21.24,56.27 21.24,53.94 22.1,53.09 22.1,50.87 21.58,50.34 21.58,43.24 22.12,42.7 22.12,38.15 25.18,35.1 31.54,35.1 v1(32.18,35.74)
  BOTTOM w0.089: CPU1.CR26 113.7,90.63 114.94,90.63 115.12,90.45 117.94,90.45 118.34,90.04 119.23,90.04 119.48,89.8 120.13,89.8 v1(120.45,89.48)
CNVI_EN#_R: length 3.4
  TOP w0.089: Q6102.G 49.9,109.11 v2(49.41,108.62) 49.41,108.13 R6110.1 48.26,108.51 R6101.1
CPU_DP1_CTRL_CLK: length 170.9
  TOP w0.114: v1(26.17,101.44) 26.68,101.96 FC8986.1 ; Q5702.4 v1(20.77,88.76)
  L3 w0.089: v1(20.77,88.76) 20.77,90.83 22.36,92.43 24.84,92.43 25.73,93.33 25.73,95.48 26.3,96.04 26.3,96.58 26.64,96.92 26.64,100.97 v1(26.17,101.44) ; v1(107.41,102.09) 107.83,101.66 107.83,101.35 108.21,100.97 110.34,100.97 110.41,100.9 111.52,100.9 113.18,102.56 117.13,102.56 117.74,103.17 118.92,103.17 119.59,102.5 123.56,102.5 124.06,103 v1(124.06,103)
  L6 w0.114: v1(26.17,101.44) 26.35,101.63 26.35,106.97 23.85,109.47 23.85,110.64 25.51,112.31 26.91,112.31 28.12,113.51 28.12,113.73 30.05,115.66 30.05,117.17 30.28,117.4 32.44,117.4 32.52,117.32 34.3,117.32 34.66,117.68 39.58,117.68 40.27,118.37 41.92,118.37 42.6,119.06 45.29,119.06 45.9,118.44 49.88,118.44 50.84,119.41 56.71,119.41 58.42,121.12 58.42,121.24 58.84,121.66 63.69,121.66 64.41,120.94 85.92,120.94 87.62,122.64 89.22,122.64 89.82,123.24 101.65,123.24 102.59,122.3 109.47,122.3 111.12,120.65 111.12,118.89 118.84,111.17 121.15,111.17 122.93,109.39 122.93,105.42 123.99,104.36 123.99,103.08 v1(124.06,103)
  BOTTOM w0.114: CPU1.CC8 v1(107.41,102.09) ; v1(26.17,101.44) v2(26.5,101.93) ; v1(124.06,103) 124.21,103 124.9,103.69 RN401.6
CPU_DP1_CTRL_DATA: length 168.7
  TOP w0.114: v1(24.97,91.72) 23.47,91.72 v2(23.37,91.62) 22.62,90.87 Q5702.1
  L3 w0.089: v1(124.44,102.49) 124.08,102.49 123.86,102.27 113.27,102.27 111.71,100.71 110.32,100.71 110.26,100.76 108.09,100.76 v1(107.41,101.45) ; v1(25.91,102.03) 26.34,102.03 26.83,101.54 26.83,94.14 26.13,93.43 26.13,93.31 26.45,92.98 26.45,92.82 26.35,92.72 26.21,92.72 25.87,93.06 25.75,93.06 25.62,92.93 25.62,92.81 25.99,92.44 25.99,92.31 25.87,92.18 25.74,92.18 25.37,92.55 25.25,92.55 24.97,92.28 v1(24.97,91.72)
  L6 w0.114: v1(25.91,102.03) 25.91,107.1 23.63,109.38 23.63,110.73 25.42,112.52 26.72,112.52 27.69,113.49 27.69,113.6 29.75,115.66 29.75,117.2 30.18,117.63 32.53,117.63 32.62,117.54 34.21,117.54 34.57,117.9 39.49,117.9 40.18,118.59 41.83,118.59 42.51,119.27 45.38,119.27 45.99,118.66 49.79,118.66 50.75,119.62 56.62,119.62 58.21,121.21 58.21,121.33 58.75,121.88 63.78,121.88 64.5,121.15 85.83,121.15 87.53,122.85 89.13,122.85 89.73,123.45 101.74,123.45 102.68,122.51 109.56,122.51 111.34,120.74 111.34,118.98 118.93,111.39 121.24,111.39 123.14,109.48 123.14,105.51 124.2,104.45 124.2,103.48 124.54,103.15 124.54,102.59 v1(124.44,102.49)
  BOTTOM w0.114: CPU1.CC9 v1(107.41,101.45) ; RN401.5 125.08,103.1 124.46,102.49 v1(124.44,102.49)
CPU_DP1_HPD: length 314.3
  TOP w0.089: v1(25.97,23.04) 25.76,23.25 25.76,26.01 25.56,26.21 25.56,28.21 26.95,29.61 26.95,32.36 27.23,32.64 27.23,34.65 28.32,35.73 29.24,36.65 v1(29.24,37.31) ; v1(31.65,23.04) 31.74,23.13 31.74,27.49 36.77,32.52 42.38,32.52 42.45,32.59 v2(47.81,32.59) 50.75,32.59 52.09,33.93 52.09,50.75 56.76,55.42 97.95,55.42 98.21,55.17 110.17,55.17 125.18,70.18 125.18,92.45 124.11,93.52 124.11,97.5 123.78,97.83 123.21,97.83 122.94,98.1 v1(122.94,103.38)
  L3 w0.089: v1(29.24,37.31) 29.24,40.54 27.3,42.48 27.3,48.57 27.45,48.72 31.8,53.07 31.8,54.6 36.26,59.06 39.68,59.06 39.93,59.31 39.93,59.88 39.42,60.38 39.42,72.51 40.19,73.28 40.19,75.29 42.01,77.12 42.01,80.08 41.51,80.59 41.51,92.46 39.78,94.18 38.49,94.18 35.03,97.64 34.04,97.64 29.27,102.41 29.27,103.59 29.62,103.94 29.62,110.97 29.16,111.44 28.58,111.44 27.69,110.54 27.21,110.54 26.34,109.68 20.72,109.68 20.09,110.31 19.94,110.31 17.1,110.31 16.06,111.35 15.39,111.35 v1(14.96,111.79)
  BOTTOM w0.076: CPU1.CN6 112.5,103.39 112.74,103.15 112.79,103.13 113.02,103.13 113.08,103.15 113.39,103.15 113.49,103.11 113.91,103.11 113.97,103.18 114.23,103.18
  BOTTOM w0.089: v1(25.97,23.04) 25.97,23 27.05,21.92 30.89,21.92 31.65,22.68 v1(31.65,23.04) ; 114.23,103.18 115.6,103.18 115.78,103.35 116.46,103.35 117.02,103.91 121.29,103.91 121.82,103.38 v1(122.94,103.38) ; v1(14.96,111.79) 14.96,111.79 14.48,111.79 14.15,112.12 R5782.1 11.46,112.57 10.7,111.81 10.7,108.74 11.45,107.98 13.18,107.98 14.8,106.36 Q5703.E
