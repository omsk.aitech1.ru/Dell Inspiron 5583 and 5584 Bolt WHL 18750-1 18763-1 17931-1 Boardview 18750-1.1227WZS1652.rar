# Allegro board 18750-1.1227WZS1652.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM: 111.08,141.83 110.9,142.01 110.9,143.26 110.8,143.36 106.71,143.36 106.61,143.46 106.61,144.1 106.68,144.17 107.55,144.17 107.83,144.45 107.83,145.44 108.05,145.67 111.94,145.67 112.02,145.59 112.02,145.21 111.59,144.78 111.59,142.24 111.66,142.17 112.5,142.17 112.5,141.83 ; 3 cut-outs
GND on BOTTOM: 88.52,137.09 88.37,137.24 88.37,138.71 90.33,140.67 90.33,141.23 91.24,141.23 91.32,141.15 91.32,138 91.16,137.85 90.43,137.85 90.38,137.8 90.38,137.09
GND on BOTTOM: 71.76,119.69 71.63,119.81 71.63,123.62 71.38,123.88 71.38,127.05 71.12,127.31 71.12,131.93 71.03,132.02 69.84,132.02 68.58,133.28 64.9,133.28 64.77,133.4 64.77,134.42 64.9,134.55 65.28,134.55 65.41,134.67 65.41,135.18 65.66,135.43 70.44,135.43 70.82,135.82 70.82,137.29 71.38,137.85 73.1,137.85 73.33,138.08 73.33,139.24 73.54,139.45 75.44,139.45 75.95,139.96 75.95,142.5 76.13,142.67 77.7,142.67 78.01,142.37 78.01,139.12 77.65,138.76 75.01,138.76 74.78,138.53 74.78,137.69 74.3,137.21 73.97,137.21 73.79,137.03 73.79,136.73 73.36,136.3 73.36,135.46 73.94,134.88 73.94,132.64 73.16,131.85 73.16,123.37 73.92,122.61 73.92,119.94 73.66,119.69 ; 5 cut-outs
GND on BOTTOM: 82.3,30.15 81.59,30.86 81.59,31.7 81.41,31.88 80.72,31.88 80.65,31.95 80.65,32.39 80.72,32.46 80.72,33.96 80.78,34.01 88.24,34.01 89.03,34.8 93.45,34.8 93.58,34.67 93.58,34.47 93.81,34.24 94.97,34.24 96.24,32.97 96.24,32.56 96.02,32.34 95.58,32.34 95.43,32.49 95.43,32.97 95.25,33.15 92.79,33.15 92.18,32.54 92.18,31.27 91.06,30.15 ; 3 cut-outs
GND on BOTTOM: 134.6,80.37 134.04,80.93 134.04,84.28 134.23,84.47 135.27,84.47 138.13,81.61 140.54,81.61 141.02,82.09 141.43,82.09 141.61,81.92 141.61,80.7 141.28,80.37 ; 3 cut-outs
GND on BOTTOM: 64.85,135.76 64.85,136.93 66.27,136.93 66.27,135.76
GND on BOTTOM: 120.65,138.48 119.76,139.37 115.7,139.37 115.57,139.5 115.57,140.13 115.7,140.26 117.73,140.26 118.11,140.64 118.11,141.78 118.24,141.91 121.29,141.91 121.42,141.78 121.42,141.07 120.75,141.07 120.5,140.82 119.79,140.82 119.61,140.64 119.61,140.16 119.99,139.78 120.68,139.78 120.86,139.6 120.86,139.24 121.16,138.94 121.16,138.74 120.91,138.48 ; 2 cut-outs
GND on BOTTOM: 191.7,46.03 191.37,46.36 191.37,47.37 191.54,47.55 192.76,47.55 192.87,47.65 192.87,48.36 192.89,48.39 195.25,48.39 195.43,48.21 195.43,47.85 194.8,47.22 194.8,46.15 194.67,46.03
GND on BOTTOM: 136.91,92.99 136.66,93.24 136.66,94.84 137.24,95.43 137.24,95.99 138.33,95.99 138.33,95.53 138.48,95.38 139.8,95.38 139.88,95.3 139.88,94.16 139.83,94.11 137.87,94.11 137.67,93.91 137.67,93.12 137.54,92.99 ; 4 cut-outs
GND on BOTTOM: 38.66,34.14 38.51,34.29 37.78,34.29 36.81,35.26 36.81,37.9 36.58,38.13 36.07,38.13 35.99,38.2 35.99,38.63 36.08,38.72 37.37,38.72 37.47,38.62 37.47,38.15 37.65,37.97 38.48,37.97 39.2,37.26 39.2,36.32 39.27,36.25 40.48,36.25 40.53,36.3 40.53,36.62 40.62,36.7 41.7,36.7 41.8,36.61 41.8,35.54 41.74,35.48 38.76,35.48 38.62,35.34 38.62,35.03 38.87,34.77 39.09,34.77 39.22,34.65 39.22,34.24 39.12,34.14
GND on BOTTOM: 69.93,36.17 69.22,36.88 69.22,38.43 69.14,38.51 68.25,38.51 68.2,38.56 68.2,38.81 68.25,38.86 69.57,38.86 69.88,38.56 69.88,37.49 70.03,37.34 71.76,37.34 71.99,37.11 71.99,36.25 71.91,36.17
GND on BOTTOM: 113.41,29.31 113.26,29.47 113.13,29.47 110.86,31.74 110.86,36.53 110.21,37.17 110.21,39.93 109.58,40.57 109.07,40.57 108.74,40.9 108.74,41.58 108.92,41.76 110.44,41.76 111.23,40.97 111.23,37.85 112.45,36.63 112.45,34.85 114.02,33.28 114.02,29.36 113.97,29.31 ; 1 cut-out
GND on BOTTOM: 104.93,139.09 104.88,139.14 104.88,140.26 104.47,140.67 104.47,141.07 104.55,141.15 106.12,141.15 106.23,141.05 106.23,140.31 106.45,140.08 108.31,140.08 108.36,140.03 108.36,139.17 108.28,139.09 ; 1 cut-out
GND on BOTTOM: 178.46,43.71 178.46,44.5 178.31,44.65 178.31,46.41 178.44,46.53 180.72,46.53 180.98,46.28 180.98,44.88 180.6,44.5 180.27,44.5 180.19,44.43 180.19,43.71
GND on BOTTOM: 81.41,138.71 81.36,138.76 81.36,142.19 81.89,142.72 85.73,142.72 85.86,142.6 85.86,141.76 85.93,141.68 85.93,138.86 85.83,138.76 85.22,138.76 84.2,139.78 84.2,141.71 84,141.91 82.17,141.91 82.16,141.9 81.98,141.9 81.77,141.68 81.77,139.55 82.05,139.27 82.05,138.76 81.99,138.71 ; 4 cut-outs
GND on BOTTOM: 138.2,105.21 138.05,105.36 138.05,105.56 138.2,105.72 138.2,106.48 139.32,106.48 139.32,105.51 139.02,105.21
GND on BOTTOM: 75.52,135.82 75.52,136.98 76.94,136.98 76.94,135.82
GND on BOTTOM: 105.16,148.26 105.03,148.39 105.03,150.47 105.26,150.7 107.78,150.7 108.28,150.19 109.43,150.19 109.6,150.37 109.6,150.5 109.68,150.57 110.8,150.57 110.87,150.5 110.87,150.27 110.98,150.17 112.07,150.17 112.12,150.12 112.12,149.86 112.02,149.76 110.92,149.76 110.87,149.71 110.87,149.45 110.75,149.33 107.9,149.33 107.55,148.97 107.55,148.54 107.27,148.26
GND on BOTTOM: 188.17,54 186.87,55.3 186.87,56.16 186.9,56.19 190.05,56.19 190.07,56.16 190.07,55.09 188.98,54
GND on BOTTOM: 160.56,102.57 160.3,102.82 160.3,104.24 159.79,104.75 159.79,107.01 159.52,107.29 158.91,107.29 158.8,107.39 158.8,107.77 158.93,107.9 160.99,107.9 161.06,107.82 161.06,107.11 161.27,106.91 162.26,106.91 162.56,107.21 164.24,107.21 164.42,107.39 164.42,110.64 165.38,110.64 165.38,107.72 165.31,107.65 165.31,106.43 166.03,105.7 166.28,105.7 166.47,105.51 166.47,105.16 164.89,105.16 162.4,104.46 160.65,102.57 ; 7 cut-outs
GND on BOTTOM: 102.42,137.85 102.34,137.92 102.34,138.84 102.24,138.94 102.24,139.73 102.39,139.88 102.67,139.88 102.87,139.68 102.87,138 102.72,137.85
GND on BOTTOM: 59.31,131.27 59.29,131.29 59.29,132.46 59.24,132.51 58.91,132.51 58.88,132.54 58.88,133.63 58.78,133.73 58.78,134.98 58.7,135.05 57.74,135.05 57.69,135.1 57.69,136.6 57.94,136.86 57.94,137.31 58.04,137.42 58.7,137.42 59.08,137.8 59.82,137.8 60.2,137.42 60.94,137.42 61.09,137.26 61.09,135.74 60.8,135.45 60.05,135.45 59.62,135.01 59.62,133.83 59.72,133.73 59.95,133.73 60.02,133.66 60.02,132.54 60,132.51 59.67,132.51 59.59,132.44 59.59,131.29 59.57,131.27 ; 3 cut-outs
GND on BOTTOM: 52,35.15 51.59,35.56 51.59,36.53 51.69,36.63 53.6,36.63 53.98,37.01 54.84,37.01 55.15,36.7 55.58,36.7 55.63,36.65 55.63,36.12 55.55,36.04 54.08,36.04 53.19,35.15 ; 1 cut-out
GND on BOTTOM: 155.98,38.08 155.98,39.55 156.49,40.06 159.34,40.06 159.44,39.96 159.44,39.63 159.31,39.5 157.91,39.5 157.81,39.4 157.81,38.08
GND on BOTTOM: 69.14,100.76 68.94,100.97 68.94,101.42 69.04,101.53 74.27,101.53 74.37,101.42 74.37,101.02 74.12,100.76
GND on BOTTOM: 151.39,98.22 150.88,98.73 150.88,106.61 151.01,106.73 153.21,106.73 153.43,106.95 154.16,106.95 154.31,106.8 154.31,102.77 155.45,101.63 155.45,98.5 155.17,98.22 ; 3 cut-outs
GND on BOTTOM: 52.28,118.09 52.12,118.24 52.12,119.2 52.35,119.43 53.67,119.43 53.88,119.64 53.88,120.04 54.31,120.47 55.1,120.47 55.86,121.24 56.44,121.24 56.59,121.08 56.59,120.85 53.83,118.09 ; 4 cut-outs
GND on BOTTOM: 51.44,130.35 51.31,130.48 51.31,132.01 51.44,132.13 57.28,132.13 57.41,132.01 57.41,130.99 57.28,130.86 53.42,130.86 52.91,130.35 ; 4 cut-outs
GND on BOTTOM: 126.55,142.11 124.31,144.35 124.31,144.71 124.69,145.09 125.56,145.09 127.59,143.05 127.59,142.75 126.95,142.11 ; 1 cut-out
GND on BOTTOM: 43.69,87.53 43.46,87.76 43.46,90.6 43.61,90.76 47.45,90.76 47.65,90.55 47.65,87.68 47.5,87.53
GND on BOTTOM: 113.39,103.23 112.93,103.68 110.16,103.68 109.86,103.99 109.86,105.92 110.16,106.22 111.43,106.22 111.53,106.12 111.92,106.12 114,108.21 115.14,108.21 121.14,114.2 121.95,114.2 122.05,114.3 122.05,114.68 122.1,114.73 122.28,114.73 122.28,115.39 122.05,115.62 122.05,116.36 122.1,116.41 124.31,116.41 124.72,116 124.72,114.73 122.69,112.7 122.69,111.56 123.9,110.34 123.9,106.86 121.62,104.57 116.72,104.57 116.72,104.55 115.4,103.23
GND on BOTTOM: 15.98,30.35 15.5,30.83 15.5,30.86 15.22,31.14 15.22,34.88 15.85,35.51 17.33,35.51 17.43,35.41 17.43,33.83 17.25,33.66 16.87,33.66 16.64,33.88 16.06,33.88 15.93,33.76 15.93,33.28 16.08,33.12 19.1,33.12 19.1,31.78 17.68,30.35 ; 2 cut-outs
GND on BOTTOM: 160.61,78.92 160.28,79.25 159.34,79.25 159.01,79.58 159.01,80.47 159.29,80.75 159.29,81.66 159.34,81.71 159.79,81.71 160.1,81.41 160.38,81.41 160.51,81.28 160.51,80.72 161.06,80.16 161.06,79.05 160.94,78.92 ; 1 cut-out
GND on BOTTOM: 119.81,36.07 119.64,36.25 119.64,37.47 120.93,38.76 120.93,40.64 121.14,40.84 122,40.84 122.35,40.49 122.35,38 122.99,37.36 122.99,36.76 122.86,36.63 121.8,36.63 121.24,36.07 ; 2 cut-outs
GND on BOTTOM: 95.76,56.69 95.76,61.27 107.7,61.27 107.83,61.14 107.83,56.82 107.7,56.69
GND on BOTTOM: 79.53,128.98 79.35,129.16 79.35,133.22 79.25,133.33 75.59,133.33 75.47,133.45 75.47,134.44 75.57,134.55 75.97,134.55 76.15,134.72 76.15,135.43 76.3,135.59 79.76,135.59 80.04,135.31 80.04,134.72 80.27,134.49 80.5,134.49 80.67,134.32 80.67,132.31 80.98,132.01 80.98,129.13 80.83,128.98
GND on L2GND: outline of 302 points within 1.05,0.76 226.24,156.24 ; 39 cut-outs
GND on L3: 97.67,89.46 98.56,89.46 98.68,89.33 98.68,86.41 98.56,86.29 98.05,86.29 97.54,86.79 97.54,89.33
GND on L3: outline of 431 points within 1.41,0.76 226.24,156.24 ; 6 cut-outs
GND on L3: 71.55,122.89 71.43,123.01 71.43,127.66 70.39,128.7 64.57,128.7 63.27,127.41 63.27,125.68 63.05,125.45 62.08,125.45 61.85,125.68 61.85,131.6 62.18,131.93 62.18,133.61 62.61,134.04 64.16,134.04 65.43,135.31 68.2,135.31 68.53,134.98 70.59,134.98 70.97,135.36 79.38,135.36 80.24,134.49 80.57,134.49 81.44,135.36 88.45,135.36 89.39,134.42 89.39,130.68 89.33,130.63 89.33,125.43 89.16,125.25 87.94,125.25 87.79,125.4 87.79,127.41 86.59,128.6 82.65,128.6 82.63,128.58 73.97,128.58 73.03,127.64 73.03,123.04 72.88,122.89
GND on L3: 96.65,119.81 98.3,118.16 99.83,118.16 99.95,118.29 99.95,125.27 99.7,125.53 97.79,125.53 97.54,125.78 97.54,128.83 97.41,128.96 96.9,128.96 96.65,128.7
GND on L4VCC: outline of 296 points within 1.05,0.76 226.24,156.24 ; 31 cut-outs
GND on L5: 76.51,135.36 78.92,135.36 79.2,135.08 79.2,133.68 78.9,133.38 75.8,133.38 75.47,133.71 75.47,134.32
GND on L5: 43.64,90.83 47.48,90.83 47.63,90.68 47.63,86.95 46.99,86.31 43.77,86.31 43.36,86.72 43.36,90.55
GND on L5: 65.1,137.03 65.1,134.67 64.62,134.19 64.62,133.68 65.05,133.25 68.38,133.25 68.68,133.55 68.68,137.49 65.56,137.49
GND on L5: 82.86,135.43 85.3,135.43 85.5,135.23 85.5,133.55 85.12,133.17 82.43,133.17 82.07,133.53 82.07,134.65
GND on L5: 143.89,153.21 150.75,153.21 151.64,152.33 156.72,152.33 158.5,150.55 158.5,147.5 159.13,146.86 159.52,146.86 159.77,147.12 159.77,147.5 159.9,147.63 160.91,147.63 161.29,147.25 161.29,146.61 165.1,142.8 165.1,140.77 164.98,140.64 162.94,140.64 162.18,141.4 161.29,141.4 161.04,141.15 161.04,138.36 159.13,136.45 159.13,126.16 157.74,124.77 157.1,124.77 156.72,124.39 156.72,123.12 158.12,121.72 160.02,121.72 160.53,121.21 160.53,121.08 160.15,120.7 159.06,120.7 158.85,120.5 158.85,120.24 158.49,119.88 158.49,118.72 159.52,117.69 159.52,116.26 157.23,113.97 152.66,113.97 152.53,114.1 150.75,114.1 150.12,114.73 149.1,114.73 148.34,115.5 145.8,115.5 139.04,122.25 139.04,123.65 138.31,124.39 138.31,125.15 138.05,125.4 138.05,126.29 137.93,126.42 137.93,126.93 139.2,128.2 139.2,128.96 139.58,129.34 139.58,129.59 142.12,132.13 142.12,133.4 142.24,133.53 143.26,133.53 143.51,133.78 144.53,133.78 145.29,134.55 145.29,136.2 145.04,136.45 141.74,136.45 141.23,136.96 138.59,136.96 138.26,136.63 137.98,136.63 137.8,136.45 137.42,136.45 132.59,141.28 132.59,144.96 136.91,149.28 139.96,149.28
GND on L5: outline of 439 points within 1.41,0.76 226.24,156.24 ; 4 cut-outs
GND on L6: 117.22,118.8 120.02,118.8 120.4,118.42 120.4,117.02 120.83,116.59 120.83,115.98 120.49,115.63 118.35,115.63 116.97,117.02 116.97,118.54
GND on L6: outline of 434 points within 1.41,0.76 226.24,156.24 ; 6 cut-outs
GND on L6: 43.87,90.86 47.48,90.86 47.63,90.7 47.63,86.95 46.99,86.31 43.77,86.31 43.69,86.39 43.69,90.68
GND on L6: 71.61,122.91 71.38,123.14 71.38,127.28 69.95,128.7 64.49,128.7 64.11,129.08 64.11,130.28 63.48,130.91 63.48,132.31 65.1,133.94 65.1,136.6 66.17,137.67 67.52,137.67 67.72,137.47 67.72,136.02 68.25,135.48 79.25,135.48 80.19,134.55 80.67,134.55 81.56,135.43 88.65,135.43 89.39,134.7 89.39,125.45 89.18,125.25 87.91,125.25 87.68,125.48 87.68,127.43 86.54,128.58 74.27,128.58 73.03,127.33 73.03,123.12 72.82,122.91
GND on L7GND: 114,28.82 113.6,29.21 113.6,29.47 112.86,30.21 112.6,30.21 111.21,31.61 106.35,31.61 105.97,31.23 101.17,31.23 98.62,33.79 98.62,35.69 97.98,36.33 97.98,37.34 97.62,37.71 98.51,37.71 98.63,37.83 103.43,37.83 105.46,35.8 112.35,35.8 114.38,37.83 117.78,37.83 118.05,37.57 118.05,31.75 117.41,31.12 117.41,29.34 116.89,28.82
GND on L7GND: outline of 266 points within 1.05,0.76 226.24,156.24 ; 33 cut-outs
VCC3PD on TOP: 52.99,125.53 52.91,125.6 52.91,125.88 53.06,126.04 53.06,127.05 52.91,127.2 52.91,127.56 53.01,127.66 54.36,127.66 54.56,127.46 54.56,126.87 54.77,126.67 54.97,126.67 55.12,126.52 55.12,125.99 55.07,125.93 53.95,125.93 53.55,125.53
VDDD on TOP: 38.74,105.59 38.61,105.72 38.61,107.88 38.74,108 39.5,108 39.63,108.13 39.63,108.76 39.75,108.89 39.88,108.89 40.01,108.76 40.01,105.72 39.88,105.59 ; 2 cut-outs
VDDD on TOP: 38.66,114.91 38.43,115.14 38.43,115.67 38.56,115.8 38.79,115.8 39.02,116.03 39.02,116.46 39.2,116.64 39.65,116.64 40.44,115.85 40.44,114.91
VDDIO on TOP: 40.26,104.8 40.14,104.93 40.14,108.76 40.26,108.89 40.39,108.89 40.52,108.76 40.52,107.29 41.33,106.48 41.33,104.9 41.23,104.8 ; 2 cut-outs
0D6V_PWR on TOP: 93.27,39.17 93.12,39.32 93.12,40.92 93.3,41.1 94.75,41.1 94.77,41.07 94.77,39.37 94.57,39.17
0D6V_PWR on BOTTOM: 117.33,28.86 117.27,28.91 117.27,29.19 117.33,29.24 118.06,29.24 118.11,29.29 118.11,29.62 118.09,29.64 117.43,29.64 117.3,29.77 117.3,29.92 117.35,29.97 118.47,29.97 118.88,30.38 121.19,30.38 121.39,30.18 121.39,28.96 121.31,28.88 121.11,28.88 120.83,29.16 118.82,29.16 118.52,28.86 ; 3 cut-outs
0D6V_S0 on TOP: 95.19,39.18 95.06,39.31 95.06,41.31 96.18,42.43 98.69,42.43 99.11,42.01 99.11,40.86 99.01,40.76 97.81,40.76 96.23,39.18 ; 2 cut-outs
0D6V_S0 on BOTTOM: 95.86,39.07 95.66,39.27 95.66,41.61 95.86,41.81 96.29,41.81 96.42,41.94 96.42,45.49 96.78,45.85 97.69,45.85 98.78,44.76 98.78,43.69 98.22,43.13 98.22,41.73 97.92,41.43 97.62,41.43 97.21,41.02 97.21,39.27 97.01,39.07 ; 5 cut-outs
0D6V_S0 on L3: 129.44,43.41 137.54,43.41 137.56,43.4 143.25,43.4 143.56,43.08 143.56,41.76 143.41,41.61 117.83,41.61 117.27,41.05 110.26,41.05 107.04,37.82 105.24,37.82 104.42,38.63 104.42,40.67 103.38,41.71 101.98,41.71 101.55,42.14 100.36,42.14 98.89,40.67 97.31,40.67 96.95,41.02 96.95,42.72 98.45,44.22 98.45,44.86 99.42,45.82 102.06,45.82 104.23,43.65 104.24,43.66 129.19,43.66
1D0V_S5 on TOP: 100.49,93.68 100.41,93.75 100.41,97.59 100.54,97.72 100.54,99.7 101.17,100.33 102.01,100.33 102.24,100.56 102.24,103.33 100.99,104.57 100.99,106.58 101.4,106.99 101.4,112.22 98.89,114.73 98.89,119.69 98.48,120.09 98.48,125.82 98.8,126.14 106.21,126.14 106.34,126.02 106.34,123.84 106.66,123.52 109.17,123.52 109.32,123.37 109.32,121.92 109.13,121.73 107.89,121.73 107.85,121.69 107.85,120.75 108,120.6 108,119.58 108.11,119.48 108.11,117.37 108.21,117.27 110.32,117.27 111.2,118.16 114.05,118.16 114.1,118.11 114.1,115.55 114.79,114.86 114.79,114.28 117.1,111.96 117.1,106.48 119.38,104.19 119.38,103.53 116.23,100.38 114.66,100.38 114.4,100.13 113.06,100.13 112.35,99.42 112.35,98.53 112.22,98.4 108.31,98.4 108.3,98.39 107.36,98.39 105.54,96.57 105.54,94.72 105.18,94.36 101.17,94.36 100.92,94.11 100.92,93.8 100.79,93.68 ; 33 cut-outs
1D0V_S5 on BOTTOM: 100.79,93.34 100.45,93.67 100.45,98.55 100.97,99.07 100.97,99.69 106.87,99.69 107.07,99.49 107.07,99.14 106.28,98.35 106.28,97.11 105.92,96.75 105.92,96.75 105.92,93.53 105.73,93.34
1D0V_S5 on L3: 105.5,97.14 105.5,93.81 105.33,93.64 100.47,93.64 100.21,93.91 100.21,125.03 100.58,125.4 100.59,125.4 104.91,125.4 105.39,124.92 105.39,124.66 107.9,122.15 107.9,119.56 112.3,115.16 112.3,108.36 111.55,107.61 110.25,107.61 107.23,104.59 107.23,98.87
1D0V_VCCPRIM_MPHY on TOP: 103.76,97.69 103.66,97.79 103.66,98.3 103.1,98.86 103.1,99.26 104.12,100.28 105.03,100.28 105.03,99.49 104.85,99.32 104.85,98.05 104.5,97.69 ; 1 cut-out
1D0V_VCCPRIM_MPHY on BOTTOM: 103.5,98.41 103.28,98.64 103.28,99.51 103.37,99.61 105.02,99.61 105.1,99.53 105.1,98.49 105.02,98.41
1D2V_S3 on TOP: 136.93,39.55 134.67,41.81 123.22,41.81 122.56,42.47 107.32,42.47 106.56,43.23 105.39,43.23 104.27,42.11 100.59,42.11 100.56,42.14 90.6,42.14 90.07,42.67 79.86,42.67 79.56,42.37 71.22,42.37 71.2,42.39 71.2,43.11 71.17,43.13 70.39,43.13 69.93,42.67 54.28,42.67 53.73,43.22 53.73,49.78 58.05,54.09 96.16,54.09 98.99,51.26 99.57,51.26 99.88,51.56 99.88,51.72 100.03,51.87 113.64,51.87 116.97,55.2 127.43,55.2 128.93,53.7 143.41,53.7 144.91,55.2 149.1,55.2 149.11,55.18 151.88,55.18 154.36,52.71 166.2,52.71 168.32,50.59 168.32,50.2 168.86,49.66 168.86,48.24 168.58,47.96 168.58,47.25 168.63,47.25 169.4,46.48 169.4,44.48 168.66,43.74 152.25,43.74 148.06,39.55 ; 69 cut-outs
1D2V_S3 on TOP: 97.79,72.01 97.59,72.21 97.59,73.51 97.49,73.61 96.5,73.61 96.14,73.97 94.26,73.97 92.66,72.37 66.35,72.37 63.27,75.44 59.82,75.44 59.52,75.74 59.52,78.74 60.07,79.3 60.43,79.3 63.38,82.25 63.38,87.96 63.68,88.27 69.98,88.27 69.99,88.28 71.55,86.72 83.7,86.72 85.25,88.27 85.52,88.27 86.24,87.56 97.21,87.56 98.91,85.85 98.91,82.22 99.16,81.97 99.16,76.35 99.47,76.05 99.47,72.24 99.24,72.01 ; 22 cut-outs
1D2V_S3 on BOTTOM: 137.42,40.13 137.34,40.21 137.34,40.84 136.91,41.28 136.05,41.28 135.92,41.15 135.56,41.15 135.44,41.28 135.44,41.73 135.51,41.81 137.82,41.81 138.31,41.33 138.31,40.26 138.18,40.13
1D2V_S3 on BOTTOM: 71.68,40.08 71.07,40.69 71.07,41.5 71.35,41.78 75.87,41.78 76.05,41.61 76.05,40.31 75.82,40.08 ; 6 cut-outs
1D2V_S3 on L3: 59.13,63.22 59.13,71.6 59.16,71.63 59.16,74.4 60.23,75.46 60.23,79 59.9,79.33 57.51,79.33 54.14,75.95 54.14,55.15 50.28,51.3 35.98,51.3 34.31,49.63 34.31,47.47 33.84,46.99 33.84,46.58 34.47,45.95 34.47,44.35 35.06,43.77 73.41,43.77 73.69,44.04 73.69,47.17 71.73,49.12 71.73,50.62
1D2V_VCCSFR_OC on TOP: 99.65,72.82 99.52,72.95 99.52,74.65 99.65,74.78 100.26,74.78 100.36,74.68 100.36,73.64 100.51,73.48 100.87,73.48 100.99,73.61 100.99,74.04 101.07,74.12 101.88,74.12 102.09,73.92 102.09,72.92 101.98,72.82 ; 1 cut-out
1D2V_VCCSFR_OC on BOTTOM: 99.67,89.56 99.29,89.94 99.29,90.6 99.44,90.76 99.98,90.76 100.16,90.58 100.16,89.74 99.98,89.56
1D2V_VCCSFR_OC on L6: 99.49,90.25 100.46,90.25 100.66,90.04 100.66,85.75 100.31,85.4 99.49,85.4 98.91,85.98 98.91,87.02 99.24,87.35 99.24,89.99
1D05V_PWR on TOP: 97.79,126.29 97.67,126.42 97.67,128.58 97.92,128.83 98.43,128.83 98.43,128.84 102.75,128.84 102.87,128.96 102.87,130.23 103.2,130.56 105.79,130.56 105.92,130.43 105.92,127.05 106.18,126.8 106.18,126.42 106.05,126.29 ; 4 cut-outs
1D05V_PWR on BOTTOM: 98.28,124.21 98.17,124.31 98.17,125.58 97.65,126.1 97.65,128.69 97.79,128.83 98.5,128.83 98.58,128.75 102.54,128.75 102.62,128.83 102.62,129.97 103.22,130.57 103.23,130.56 105.77,130.56 105.92,130.4 105.92,128.75 105.46,128.3 105.46,125.81 105.18,125.53 103.64,125.53 102.31,124.21 ; 8 cut-outs
1D8V_1V_VGA_S0 on TOP: 127.82,147.35 127.54,147.63 127.54,147.88 127.59,147.93 127.82,147.93 128.2,148.31 128.2,149.02 128.55,149.38 128.55,150.06 128.65,150.17 130.58,150.17 130.66,150.09 130.66,148.79 130.94,148.52 131.32,148.52 131.45,148.39 131.45,147.75 131.04,147.35 ; 3 cut-outs
1D8V_1V_VGA_S0 on TOP: 134.57,125.48 134.04,126.01 133.56,126.01 133.2,125.66 133.02,125.66 132.39,126.29 132.39,126.37 132.9,126.87 133.02,126.87 133.3,126.59 133.58,126.59 134.12,127.13 134.7,127.13 135.49,126.34 135.49,126.06 134.9,125.48 ; 1 cut-out
1D8V_1V_VGA_S0 on BOTTOM: 127,132.89 126.9,133 126.9,133.91 127.03,134.04 127.26,134.04 128.02,134.8 128.02,135.69 128.78,136.45 128.91,136.45 129.16,136.2 129.16,135.82 129.29,135.69 129.42,135.69 130.43,136.7 130.43,137.09 130.31,137.21 130.31,138.1 130.43,138.23 130.81,138.23 131.7,139.12 131.7,139.24 133.35,140.9 133.35,146.1 134.12,146.86 134.24,146.86 134.37,146.74 134.37,146.1 133.86,145.59 133.86,139.24 127.51,132.89
1D8V_1V_VGA_S0 on BOTTOM: 133.48,145.72 133.35,145.85 133.35,146.61 132.85,147.12 130.18,147.12 129.29,148.01 129.29,148.64 129.67,149.02 129.67,149.4 129.16,149.91 129.16,149.99 129.49,150.32 129.57,150.32 131.04,148.85 133.66,148.85 134.24,148.26 134.24,146.1 133.86,145.72 ; 2 cut-outs
1D8V_1V_VGA_S0 on L3: 127.69,135.79 128.55,134.93 129.52,134.93 132.44,137.85 132.44,147.55 131.5,148.49 130.2,148.49 128.3,146.58 128.3,137.24 127.69,136.63
1D8V_1V_VGA_S0 on L6: 128.95,136.37 129.21,136.11 130.47,136.11 132.51,134.06 132.51,133.48 132.9,133.1 132.9,131.12 131.98,130.2 131.98,129.49 131.99,129.48 131.99,129.22 132.92,128.3 133.94,128.3 134.5,127.74 134.5,127.2 133.76,126.47 132.95,126.47 130.15,129.26 130.15,131.37 130.58,131.8 130.58,133.38 129.42,134.55 128.81,134.55 127.97,135.38 127.97,135.61 128.72,136.37
1D8V_AON_S0 on BOTTOM: 136.53,105.21 136.4,105.34 136.4,105.59 136.71,105.89 136.71,106.48 137.82,106.48 137.82,105.44 137.59,105.21
1D8V_AON_S0 on BOTTOM: 148.29,116.87 148.14,117.02 148.14,117.45 148.54,117.86 148.54,118.26 148.77,118.49 149.41,118.49 149.48,118.57 149.48,119.05 149.69,119.25 150.8,119.25 150.83,119.23 150.83,118.19 149.89,118.19 148.57,116.87
1D8V_AON_S0 on BOTTOM: 161.37,107.27 161.29,107.34 161.29,108.46 161.52,108.69 164.21,108.69 164.21,107.72 164.06,107.57 162.44,107.57 162.13,107.27 ; 1 cut-out
1D8V_AON_S0 on BOTTOM: 130.5,112.79 129.97,113.31 129.67,113.31 129.34,112.98 129.26,112.98 128.7,113.54 128.7,113.64 128.5,113.84 128.5,113.97 127.61,114.86 126.5,114.86 126.37,114.73 125.96,114.73 125.86,114.83 125.86,115.19 125.94,115.27 126.7,115.27 126.72,115.24 127.31,115.24 127.54,115.47 127.97,115.47 129.06,114.38 129.06,114.15 129.28,113.93 129.76,113.93 130.38,114.56 130.53,114.56 131.4,113.69 131.4,113.49 130.7,112.79 ; 1 cut-out
1D8V_AON_S0 on L5: 123.37,129.85 123.75,130.23 123.8,130.23 125.4,131.83 128.4,131.83 128.81,131.42 128.81,130.91 128.07,130.18 128.07,129.8 128.08,129.78 128.08,128.77 127.73,128.41 127.5,128.41 126.95,128.96 126.95,130.13 126.47,130.61 125.15,130.61 123.9,129.36 123.47,129.36 123.37,129.47
1D8V_FBA_PLL_AVDD on TOP: 136.66,132.01 136.27,132.39 136.27,132.51 136.4,132.64 136.4,132.89 136.02,133.28 135.89,133.28 135.77,133.15 134.88,133.15 134.75,133.02 134.5,133.02 133.86,133.66 133.86,133.78 133.99,133.91 133.99,134.16 133.73,134.42 133.48,134.42 133.23,134.16 132.85,134.16 132.34,133.66 132.08,133.66 131.58,134.16 131.58,134.42 134.12,136.96 134.75,136.96 137.42,134.29 137.42,132.64 136.78,132.01 ; 2 cut-outs
1D8V_FBA_PLL_AVDD on L6: 137.42,135.82 136.4,135.82 135.89,135.31 135.26,135.31 134.62,134.67 134.62,132.26 138.81,128.07 139.07,128.07 139.58,128.58 139.58,131.09 141.51,133.02 141.51,133.3 141.38,133.43 141.15,133.43 141.13,133.4 138.97,133.4 137.9,134.47 137.9,135.23 139.09,136.42 139.09,136.78 138.92,136.96 138.56,136.96
1D8V_GPU_AON_S0 on TOP: 163.88,107.19 163.58,107.49 163.58,108.87 163.68,108.97 164.37,108.97 164.47,108.87 164.47,108.46 164.67,108.26 167.64,108.26 167.8,108.1 167.8,107.34 167.64,107.19 ; 1 cut-out
1D8V_GPU_AON_S0 on BOTTOM: 166.83,106.55 166.7,106.68 166.7,107.27 166.27,107.7 165.66,107.7 165.59,107.77 165.59,108.69 166.17,108.69 166.5,108.36 166.78,108.36 166.98,108.56 166.98,110.08 166.83,110.24 166.42,110.24 166.27,110.08 165.59,110.08 165.59,110.95 166.02,111.38 167.8,111.38 167.92,111.25 167.92,106.94 167.54,106.55 ; 2 cut-outs
1D8V_S0 on BOTTOM: 60.28,38.56 60.28,39.4 60.4,39.52 61.09,39.52 61.5,39.93 61.5,40.29 61.75,40.54 63.1,40.54 63.73,39.9 63.73,39.04 63.66,38.96 62.23,38.96 61.83,38.56 ; 2 cut-outs
1D8V_S5 on TOP: 57.76,39.93 57.1,40.59 57.1,41.99 57.41,42.29 60.53,42.29 60.66,42.17 60.66,40.06 60.53,39.93
1D8V_S5 on TOP: 99.01,51.39 98.17,52.22 98.17,53.16 98.66,53.65 111.76,53.65 123.19,65.08 123.27,65.08 124.67,66.47 125.89,66.47 126.16,66.19 126.16,65.13 113.16,52.12 100,52.12 99.67,51.79 99.67,51.61 99.44,51.39
1D8V_S5 on TOP: 162.54,61.16 160.51,63.2 160.51,69.22 160.23,69.5 160.23,70.46 160.3,70.54 161.39,70.54 161.88,70.05 161.88,69.11 162.59,68.4 162.59,64.29 163.9,62.98 163.9,61.74 163.33,61.16
1D8V_S5 on BOTTOM: 166.02,105.94 165.43,106.53 165.43,107.39 165.53,107.49 166.17,107.49 166.4,107.27 166.4,106.71 166.7,106.4 166.7,106.12 166.53,105.94
1D8V_S5 on BOTTOM: 58.17,38.53 58.12,38.58 58.12,40.92 57.92,41.12 57.23,41.12 57.08,41.28 57.08,41.73 57.18,41.84 59.49,41.84 59.54,41.78 59.54,39.85 58.91,39.22 58.91,38.56 58.88,38.53
1D8V_S5 on BOTTOM: 160.81,68.66 160.28,69.19 160.28,70.26 160.51,70.49 172.49,70.49 173.13,69.85 173.13,69.01 172.77,68.66
1D8V_S5 on L5: 61.73,41.33 62.33,41.33 63.86,42.85 67.47,42.85 67.8,43.18 99.22,43.18 100.74,44.71 101.53,44.71 102.01,44.22 102.01,42.47 101.15,41.61 100.46,41.61 99.11,40.26 65.76,40.26 64.8,39.3 61.04,39.3 59.69,40.64 56.92,40.64 56.62,40.95 56.62,42.44 56.85,42.67 60.38,42.67
1D8V_S5 on L6: 100.59,42.98 101.22,42.98 102.24,43.99 102.24,49.51 98.73,53.01 97.67,53.01 97.16,52.5 97.16,51.74 100.33,48.57 100.33,43.23
1D8V_S5 on L6: 131.02,61.93 155.73,61.93 156.16,62.36 158.4,62.36 158.83,61.93 161.52,61.93 161.78,62.18 164.57,62.18 164.87,61.88 164.87,60.73 164.62,60.48 163.4,60.48 162.92,60 129.29,60 124.03,65.25 124.03,65.28 123.68,65.63 123.68,66.4 123.73,66.45 126.88,66.45 127.66,65.66 127.66,65.28
1D8V_VCCPRIM on TOP: 160.28,70.89 160.23,70.94 160.23,72.39 159.31,73.31 159.31,73.66 159.62,73.97 160.4,73.97 161.24,73.13 161.24,70.97 161.17,70.89
1D8V_VCCPRIM on TOP: 126.6,65.25 126.32,65.53 126.32,68 130.05,71.73 135.89,71.73 136.83,72.67 137.57,72.67 138.01,73.12 138.01,73.5 138.31,73.79 139.45,73.79 139.65,73.59 139.65,72.44 138.13,70.92 137.65,70.92 137.49,70.77 137.49,70.36 137.33,70.19 133.01,70.19 133,70.21 132.49,70.21 129.04,66.75 129.04,65.61 128.69,65.27 128.13,65.27 128.12,65.25 ; 3 cut-outs
1D8V_VCCPRIM on TOP: 113.49,91.82 113.31,92 113.31,92.58 113.44,92.71 113.87,92.71 114.18,93.02 114.68,93.02 115.93,94.26 115.93,94.97 115.83,95.07 114.91,95.07 114.84,95.15 114.84,95.38 114.46,95.76 113.87,95.76 113.21,96.42 112.3,96.42 112.19,96.32 111.59,96.32 111.46,96.45 111.46,96.55 108.56,96.55 108.33,96.32 108.33,95.45 108.21,95.33 107.04,95.33 106.94,95.43 106.94,97.26 107.09,97.41 107.37,97.41 107.57,97.61 111.53,97.61 111.74,97.82 112.32,97.82 112.55,98.05 113.41,98.05 114.45,97.01 116.23,97.01 117.55,95.69 117.55,92.58 116.79,91.82 ; 7 cut-outs
1D8V_VCCPRIM on BOTTOM: 106.78,95.05 106.68,95.15 106.68,96.14 107.06,96.52 107.06,97.03 107.01,97.08 106.43,97.08 106.33,97.18 106.33,97.64 106.61,97.92 108.03,97.92 108.16,97.79 108.16,95.23 108.03,95.1 107.7,95.1 107.65,95.05
1D8V_VCCPRIM on BOTTOM: 137.82,72.92 137.59,73.15 137.59,73.46 138.08,73.94 159.82,73.94 160.1,73.66 160.1,73.2 159.82,72.92
1D8V_VCCPRIM on L3: 106.3,97.59 106.3,95.22 106.35,95.18 111.99,95.18 113.77,93.4 113.77,92.41 114.23,91.95 115.7,91.95 115.85,92.1 115.85,96.32 115.22,96.95 111.76,96.95 111.51,96.7 108.21,96.7 108.08,96.83 108.08,97.59 107.95,97.72 106.43,97.72
1D8V_VCCPRIM on L5: 124.46,68.02 125.45,68.02 127.26,66.22 127.26,64.85 126.67,64.26 125.25,64.26 123.7,65.81 123.7,67.26
1D8V_VCCPRIM on L6: 110.1,88.01 110.8,88.01 114.63,91.85 114.63,92.64 114.2,93.07 112.32,93.07 109.34,90.08 109.34,88.77
1D8V_VGA_PLL on TOP: 132.34,122.61 131.42,123.52 130.79,123.52 130.27,124.04 130.27,124.05 129.72,124.6 129.72,125.58 129.92,125.78 130.51,125.78 131.88,124.41 132.18,124.41 133.73,125.96 133.91,125.96 134.55,125.32 134.55,125.2 134.12,124.77 133.68,124.77 132.69,123.78 132.69,123.57 133.06,123.2 133.06,122.7 132.97,122.61
1D8V_VGA_S0 on TOP: 134.42,123.45 134.09,123.78 134.09,123.9 134.34,124.16 134.34,124.26 134.66,124.58 134.81,124.58 135.16,124.92 135.16,125.02 134.9,125.27 134.9,125.3 135.11,125.5 135.21,125.5 135.63,125.08 135.63,124.47 134.6,123.45 ; 1 cut-out
1D8V_VGA_S0 on BOTTOM: 163.17,110.08 162.26,111 161.62,111 161.42,111.2 161.42,111.69 161.55,111.81 163.35,111.81 163.71,112.17 164.37,112.17 164.44,112.09 164.44,111.1 164.21,110.87 164.21,110.08 ; 3 cut-outs
1D8V_VGA_S0 on L5: 135.03,125.07 135.74,125.78 135.74,126.14 136.17,126.57 137.29,126.57 138.1,125.76 138.1,125.2 138.2,125.1 138.2,124.84 138.9,124.14 138.9,122.06 139.25,121.72 139.25,118.8 139.37,118.67 139.37,118.06 139.12,117.81 138.89,117.81 137.95,118.75 137.95,122.89 136.45,124.39 135.64,124.39 134.99,123.73 134.63,123.73 134.42,123.93 134.42,124.45 135.03,125.06
1D8V_VGA_S0 on L6: 138.09,118.78 137.9,118.97 137.93,119 137.93,122.76 136.78,123.9 135,123.9 134.88,123.78 133.25,123.78 126.85,130.18 126.85,131.47 127.82,132.44 127.82,133.17 127.89,133.25 129.9,133.25 130.15,133 130.15,131.93 129.82,131.6 129.82,129.52 134.12,125.22 134.95,125.22 134.98,125.2 137.54,125.2 137.9,124.84 137.9,124.23 138.76,123.37 138.76,120.52 139.86,119.43 139.86,112.09 142.12,109.83 151.21,109.83 152.5,111.13 153.17,111.13 153.27,111.02 153.27,110.39 151.49,108.61 141.02,108.61 138.09,111.55
1D24V_VCCDPHY on BOTTOM: 104.75,91.72 104.68,91.8 104.68,92.79 104.8,92.91 105.59,92.91 105.79,92.71 105.79,91.82 105.69,91.72
1D35V_PWR on TOP: 116.82,145.34 115.78,146.38 115.78,149.96 115.85,150.04 116.74,150.04 116.87,150.17 116.87,150.32 117.05,150.5 120.3,150.5 120.65,150.14 120.65,145.47 120.53,145.34 ; 2 cut-outs
1D35V_PWR on BOTTOM: 118.6,144.63 117.86,145.37 117.86,149 117.3,149.56 117.3,150.45 117.53,150.67 120.48,150.67 120.78,150.37 120.78,144.66 120.75,144.63 ; 3 cut-outs
1D35V_VGA_S0 on TOP: 148.09,115.37 147.67,115.78 146.27,115.78 138.18,123.88 138.18,124.64 137.29,125.53 137.29,126.42 137.67,126.8 137.67,127.05 136.91,127.81 136.91,128.07 137.98,129.13 137.98,129.24 138.95,130.21 138.94,130.23 138.94,132.39 137.82,133.5 137.82,134.19 134.83,137.19 133.15,137.19 132.67,136.7 131.4,136.7 127.99,140.11 127.99,141.61 125.28,144.32 125.28,144.71 121.47,144.71 121.03,145.14 121.03,148.62 121.14,148.72 122.69,148.72 123.14,148.26 125.91,148.26 127.09,147.08 130.37,147.08 131.24,146.2 132.44,146.2 132.59,146.36 135.13,146.36 136.02,147.25 136.02,151.18 136.4,151.56 140.34,151.56 142.59,153.81 143.86,153.81 145.06,155.02 150.12,155.02 151.39,153.75 151.39,152.58 152.28,151.69 162.44,151.69 162.56,151.56 167.39,151.56 168.25,150.7 168.25,145.26 168.02,145.04 168.02,137.47 167.52,136.96 161.93,136.96 161.67,136.7 161.67,130.48 162.18,129.97 167.52,129.97 168.02,129.47 168.02,116.13 167.26,115.37 ; 61 cut-outs
1D35V_VGA_S0 on BOTTOM: 155.83,123.75 154.94,124.64 154.94,125.27 155.07,125.4 155.45,125.4 156.21,124.64 156.85,124.64 156.98,124.77 157.74,124.77 159.39,126.42 162.94,126.42 163.2,126.16 163.2,125.78 162.69,125.27 161.29,125.27 161.04,125.02 161.04,124.89 160.91,124.77 160.66,124.77 160.53,124.89 160.53,125.4 160.4,125.53 159.64,125.53 158.25,124.13 158.25,124 157.99,123.75
1D35V_VGA_S0 on BOTTOM: 136.99,127 136.78,127.2 136.78,128.09 139.7,131.01 139.7,132.94 134.37,138.28 134.37,139.14 134.47,139.24 134.78,139.24 139.32,134.7 139.6,134.7 139.75,134.85 139.75,135 139.88,135.13 140.19,135.13 140.44,134.88 140.44,134.16 140.49,134.11 140.77,134.11 141.02,133.86 141.02,133 141.71,132.31 142.34,132.31 142.62,132.03 142.62,131.22 142.57,131.17 141.1,131.17 140.95,131.01 140.95,130.74 140.16,129.95 139.88,129.95 139.2,129.26 139.2,129.01 138.59,128.4 138.59,127.18 138.41,127
1D35V_VGA_S0 on BOTTOM: 158.63,146.69 158.55,146.76 158.55,147.04 159.01,147.5 159.01,147.85 158.91,147.96 158.7,147.96 158.19,147.45 157.79,147.45 157.28,147.96 157.28,148.26 157.43,148.41 157.71,148.41 157.84,148.29 158.09,148.29 158.68,148.87 158.68,149.12 158.65,149.15 154.44,149.15 154.44,152.45 154.69,152.71 158.12,152.71 158.56,152.26 158.56,151.63 158.63,151.56 158.63,150.8 159.26,150.17 159.26,149.28 159.46,149.07 159.46,148.29 159.82,147.93 159.82,147.55 158.96,146.69 ; 2 cut-outs
1D35V_VGA_S0 on BOTTOM: 127.61,142.01 127.49,142.14 127.49,142.55 127.79,142.85 127.79,143.03 125.63,145.19 123.14,145.19 122.86,145.47 121.03,145.47 120.91,145.59 120.91,148.52 121.03,148.64 125.68,148.64 129.85,144.48 129.85,143.79 128.07,142.01 ; 11 cut-outs
1D35V_VGA_S0 on BOTTOM: 154.69,140.29 154.56,140.41 154.56,140.72 155.07,141.23 155.07,142.22 154.89,142.39 154.89,142.8 155.04,142.95 157.76,142.95 158.04,142.67 158.04,142.52 157.46,141.94 157.1,141.94 156.72,142.32 156.11,142.32 155.4,141.61 155.4,141.2 155.55,141.05 155.55,140.84 154.99,140.29
1D35V_VGA_S0 on BOTTOM: 165.38,114.76 164.06,116.08 162.11,116.08 161.7,116.49 161.7,118.06 160.96,118.8 160.96,119.18 161.06,119.28 161.32,119.28 163.05,117.55 167.26,117.55 167.49,117.78 167.49,120.78 166.65,121.62 166.12,121.62 166.12,119.05 165.87,118.8 164.34,118.8 164.09,119.05 164.09,119.81 162.94,120.96 162.94,124.39 163.33,124.77 165.48,124.77 166.12,124.13 166.12,123.98 166.4,123.7 167.34,123.7 167.62,123.98 167.62,130.18 167.14,130.66 166.6,130.66 166.5,130.56 166.5,127.05 166.75,126.8 166.75,126.54 166.25,126.04 165.87,126.04 165.61,126.29 165.61,127.05 165.1,127.56 163.2,127.56 162.44,126.8 161.93,126.8 161.67,127.05 161.67,128.45 162.44,129.21 162.44,137.47 161.8,138.1 161.8,140.03 162.49,140.72 162.99,140.72 162.99,142.37 162.82,142.55 162.82,144.58 163.33,145.09 163.33,146.99 162.39,146.99 162.39,146.94 162.13,146.69 161.85,146.69 161.04,147.5 161.04,148.95 161.29,149.2 161.29,150.93 161.98,151.61 167.62,151.61 168.05,151.18 168.05,150.9 168.2,150.75 168.2,145.29 168.05,145.14 168.05,115.37 167.44,114.76 ; 12 cut-outs
1D35V_VGA_S0 on BOTTOM: 154.69,114.61 154.05,115.24 154.05,117.15 154.56,117.65 158.88,117.65 159.13,117.4 159.13,115.11 158.63,114.61 ; 4 cut-outs
1D35V_VGA_S0 on BOTTOM: 158.5,117.91 157.23,119.18 157.23,119.69 157.36,119.81 157.74,119.81 158.75,118.8 158.88,118.8 159.01,118.92 159.01,119.05 158.5,119.56 158.5,119.94 158.63,120.07 159.01,120.07 159.9,119.18 159.9,118.92 158.88,117.91
1D35V_VGA_S0 on BOTTOM: 156.21,138.13 156.04,138.3 156.04,138.86 156.29,139.12 158.63,139.12 158.75,139.24 157.74,140.26 157.74,140.64 158.63,141.53 159.77,141.53 160.28,141.02 160.28,140.64 159.9,140.26 159.39,140.26 158.93,140.72 158.7,140.72 158.58,140.59 158.58,140.41 159.11,139.88 159.11,138.38 158.85,138.13
1D35V_VGA_S0 on BOTTOM: 157.86,126.04 157.81,126.09 157.81,126.72 157.05,127.48 154.79,127.48 154.18,128.09 154.18,129.69 154.59,130.1 157.61,130.1 158.25,129.47 158.25,128.65 158.98,127.92 158.98,126.82 158.19,126.04 ; 3 cut-outs
1D35V_VGA_S0 on BOTTOM: 154.82,118.67 154.56,118.92 154.56,119.31 154.94,119.69 154.94,120.83 155.45,121.34 157.23,121.34 157.48,121.08 157.48,119.94 156.21,118.67
1D35V_VGA_S0 on L3: 156.09,126.16 156.34,125.91 156.34,125.66 155.45,124.77 154.94,124.77 154.05,125.66 154.05,125.91 154.31,126.16
1D35V_VGA_S0 on L3: 154.94,120.45 158.63,120.45 159.52,119.56 159.52,118.67 159.9,118.29 160.91,118.29 161.17,118.54 161.17,118.8 161.29,118.92 161.8,118.92 162.06,118.67 162.06,118.42 162.31,118.16 162.56,118.16 163.2,117.53 164.21,117.53 164.6,117.15 164.6,116.77 164.47,116.64 161.8,116.64 161.29,117.15 160.4,117.15 160.15,117.4 160.02,117.4 159.26,118.16 158.37,118.16 157.61,118.92 155.2,118.92 154.31,118.04 154.31,117.65 154.69,117.27 154.69,116.89 154.56,116.77 153.93,116.77 153.55,117.15 153.55,118.54 154.05,119.05 154.31,119.05 154.69,119.43 154.69,120.19
1D35V_VGA_S0 on L3: 155.83,141.28 160.15,141.28 160.28,141.15 160.28,140.64 160.02,140.39 160.02,139.24 158.88,138.1 154.44,138.1 154.18,138.36 154.18,138.86 154.69,139.37 154.69,142.67 154.82,142.8 155.45,142.8 155.71,142.55 155.71,141.4
1D35V_VGA_S0 on L3: 164.6,147.63 165.87,147.63 165.99,147.5 165.99,146.99 167.01,145.98 167.01,142.04 166.75,141.78 166.75,140.64 166.63,140.51 166.25,140.51 165.99,140.77 165.99,141.02 165.61,141.4 165.48,141.4 164.85,142.04 162.69,142.04 162.66,142.06 157.28,142.06 157,142.34 157,142.93 157.33,143.26 163.02,143.26 165.1,145.34 165.1,146.74 164.85,146.99 164.72,146.99 164.47,147.25 164.47,147.5
1D35V_VGA_S0 on L3: 162.16,149.99 164.16,149.99 164.37,149.79 164.37,149.45 164.24,149.33 162.18,149.33 162.03,149.48 162.03,149.86
1D35V_VGA_S0 on L3: 164.6,119.05 165.87,119.05 166.12,119.31 166.12,125.73 164.95,126.9 164.7,126.9 164.49,126.7 164.49,126.34 165.24,125.59 165.24,124.52 165.1,124.39 165.1,122.73 163.71,121.34 163.71,119.94 163.83,119.81 164.21,119.81 164.34,119.69 164.34,119.31
1D35V_VGA_S0 on L3: 142.37,138.36 143.51,138.36 147.2,134.67 147.2,134.29 146.43,133.53 145.93,133.53 145.04,132.64 145.04,131.75 144.91,131.62 142.24,131.62 138.94,128.32 138.94,127.81 138.43,127.31 137.67,127.31 136.91,128.07 136.91,130.35 137.8,131.24 138.43,131.24 139.2,132.01 139.2,133.28 136.91,135.56 136.02,135.56 134.12,137.47 134.12,138.61 134.5,138.99 135.26,138.99 137.67,136.58 138.56,136.58 139.2,137.21 141.23,137.21
1D35V_VGA_S0 on L3: 159.34,127.69 157.48,127.69 157.33,127.53 157.33,127.31 157.97,126.67 157.97,126.26 158.98,125.25 160,125.25 160.38,124.87 160.91,124.87 161.37,125.32 162.66,125.32 162.84,125.5 162.84,126.04 162.54,126.34 160.68,126.34
1D35V_VGA_S0 on L3: 154.56,150.17 159.39,150.17 160.02,149.53 160.66,149.53 161.8,148.39 161.8,147.12 161.67,146.99 161.42,146.99 160.4,148.01 159.9,148.01 159.64,147.75 159.64,147.25 158.3,145.9 157.36,145.9 157.36,145.47 157.23,145.34 155.07,145.34 154.31,146.1 154.31,149.91
1D35V_VGA_S0 on L5: outline of 103 points within 121.54,114.73 168.02,155.5
1D35V_VGA_S0 on L6: 144.53,131.5 144.28,131.75 144.28,132.01 144.66,132.39 144.66,133.02 145.42,133.78 147.07,133.78 148.59,132.26 148.85,132.26 149.1,132.01 149.1,131.75 148.85,131.5 147.96,131.5 147.83,131.37 145.55,131.37 145.29,131.62 144.91,131.62 144.78,131.5
1D35V_VGA_S0 on L6: outline of 81 points within 138.05,114.73 168.2,155.37
2D5V_S3 on TOP: 172.72,49 172.39,49.33 172.39,50.37 172.7,50.67 173.54,50.67 173.69,50.52 173.69,49.2 173.49,49 ; 1 cut-out
2D5V_S3 on BOTTOM: 172.72,49.3 172.39,49.63 172.39,51.92 172.67,52.2 172.67,52.81 172.77,52.91 173.18,52.91 173.51,52.58 173.51,49.71 173.1,49.3
3D3V_AON_1D8V_VGA_S0 on BOTTOM: 126.01,132.18 125.63,132.56 125.63,133.33 125.76,133.45 126.62,133.45 126.77,133.3 126.77,132.44 126.52,132.18
3D3V_AUX_S5 on L2GND: 209.38,56.76 209.24,56.9 209.24,58.17 205.82,61.58 182.2,61.58 175.47,68.31 173.06,68.31 171.01,70.36 171.01,71.76 164.04,78.73 163.15,78.73 161.86,80.01 161.86,88.37 162.13,88.63 162.61,88.63 162.75,88.49 162.75,81.51 171.9,72.36 171.9,71.47 173.79,69.58 175.18,69.58 182.55,62.22 207.44,62.22 211.52,58.14 211.52,57.15 211.13,56.76
3D3V_CAMERA on BOTTOM: 158.5,103.68 158.17,104.01 158.17,104.7 158.88,104.7 159.03,104.55 159.31,104.55 159.59,104.27 159.59,103.86 159.41,103.68
3D3V_CAMERA_S0 on TOP: 215.65,42.7 215.22,43.13 215.22,43.77 215.7,44.25 217.88,44.25 218.72,45.09 218.72,45.85 219.31,46.43 220.17,46.43 220.45,46.15 220.45,45.7 220.35,45.59 219.71,45.59 219.5,45.38 219.5,44.79 217.4,42.7
3D3V_CAMERA_S0 on BOTTOM: 212.3,43.31 212.17,43.44 212.17,44.02 212.91,44.76 216.11,44.76 216.61,44.25 216.61,43.89 216.44,43.71 216.16,43.71 215.9,43.97 213.54,43.97 212.88,43.31 ; 3 cut-outs
3D3V_CAMERA_S0 on L6: 181.28,70.44 181.71,70.44 183.31,68.84 183.8,68.68 185.78,68.68 186.06,68.63 187.2,68.25 189.78,65.67 189.78,64.33 188.27,62.82 184.25,62.82 182.63,64.44 182.63,67.67 181.18,69.11 181.18,70.33
3D3V_LAN_S5 on TOP: 47.78,84.43 47.73,84.48 47.73,84.63 47.81,84.71 48.49,84.71 49.03,85.24 49.36,85.24 49.69,85.57 50.47,85.57 50.57,85.47 50.57,84.91 50.37,84.71 49.53,84.71 49.25,84.43
3D3V_LAN_S5 on TOP: 43.08,85.14 41.76,86.46 41.76,87.91 41.94,88.09 42.68,88.09 42.85,87.91 42.85,87.07 43.54,86.39 44.48,86.39 44.83,86.03 44.83,85.19 44.78,85.14
3D3V_LAN_S5 on BOTTOM: 45.52,79.96 45.04,80.44 45.04,81.23 45.34,81.54 45.8,81.54 46.18,81.15 48.34,81.15 48.87,81.69 48.87,81.76 49.05,81.94 49.3,81.94 49.48,81.76 49.48,81.31 48.95,80.77 48.95,80.06 48.85,79.96 ; 2 cut-outs
3D3V_LAN_S5_R on TOP: 42.85,132.84 42.65,133.05 42.65,133.83 43.26,134.44 45.42,134.44 45.9,133.96 45.9,133.2 45.88,133.17 45.27,133.17 44.94,133.5 43.56,133.5 43.36,133.3 43.36,133.1 43.11,132.84
3D3V_LCDVDD_S0 on TOP: 216.97,38.79 216.26,39.5 216.26,40.44 216.33,40.51 219.26,40.51 219.31,40.46 219.31,39.04 219.05,38.79 ; 2 cut-outs
3D3V_LCDVDD_S0 on BOTTOM: 218.34,40.21 219.33,40.21 219.33,38.89 217.78,38.89 216.89,39.78 216.89,40.59 217.15,40.84 217.71,40.84
3D3V_LCDVDD_S0 on BOTTOM: 209.38,51.92 209.1,52.2 209.1,53.75 209.25,53.9 210.47,53.9 210.59,53.77 210.59,53.34 210.06,52.81 210.06,51.92
3D3V_LCDVDD_S0 on L6: 209.3,53.9 211.84,53.9 212.78,52.96 212.78,51.87 213.19,51.46 214.96,51.46 215.9,50.52 215.9,49.71 216.44,49.18 216.44,46 218.32,44.12 218.32,39.17 217.94,38.79 217.12,38.79 216.16,39.75 214.81,39.75 212.22,42.34 212.22,48.57 211.33,49.46 210.82,49.46 210.32,49.96 210.32,52.12 209.17,53.27 209.17,53.77
3D3V_RTC_AUX_S5 on TOP: 166.37,68.28 166.22,68.43 166.22,68.96 167.31,70.05 169.45,70.05 169.8,69.7 169.8,68.51 169.57,68.28 ; 1 cut-out
3D3V_S0 on TOP: 45.22,101.68 44.76,102.13 44.76,103.07 45.34,103.66 45.34,104.17 45.47,104.29 46.87,104.29 46.99,104.17 46.99,102.97 46.89,102.87 46.66,102.87 46.59,102.8 46.59,102.16 46.1,101.68 ; 1 cut-out
3D3V_S0 on TOP: outline of 86 points within 122.33,95.3 137.9,121.21 ; 6 cut-outs
3D3V_S0 on TOP: 43.01,28.4 42.66,28.75 42.66,30.16 44.05,31.55 51.57,31.55 53.8,33.78 53.8,36.15 53.39,36.55 53.39,39.98 54.36,40.95 54.36,41.58 54.74,41.96 56.62,41.96 57,41.58 57,40.49 57.36,40.13 57.36,36.35 57,35.99 57,35.41 57.23,35.18 57.23,34.37 56.65,33.78 56.65,32.84 56.92,32.56 56.92,30.3 55.53,28.91 55.25,28.91 54.75,28.4 ; 6 cut-outs
3D3V_S0 on TOP: 196.09,34.47 195.96,34.6 195.96,35.74 196.09,35.87 197.36,35.87 197.49,35.74 197.49,34.6 197.36,34.47 ; 1 cut-out
3D3V_S0 on TOP: 43.54,129.39 43.31,129.62 43.31,131.55 43.56,131.8 45.85,131.8 45.88,131.78 45.88,131.17 45.49,130.79 45.49,129.95 44.94,129.39
3D3V_S0 on TOP: 148.09,32.41 147.78,32.72 147.78,35.43 149.36,37.01 149.36,40.39 152.45,43.49 169.29,43.49 170.18,44.38 170.18,52 172.7,54.51 175.24,54.51 175.39,54.66 176.1,54.66 176.25,54.51 176.25,52.38 175.44,51.56 172.7,51.56 172.27,51.13 172.27,47.14 172.52,46.89 172.52,44.93 172.47,44.88 172.01,44.88 171.96,44.83 171.96,42.85 169.14,40.03 168.66,40.03 168.58,40.11 168.58,40.62 168.43,40.77 153.62,40.77 152.28,39.42 152.28,36.15 151.01,34.88 151.01,32.87 150.55,32.41 ; 11 cut-outs
3D3V_S0 on TOP: 222.79,63.09 222.38,63.5 222.38,64.85 222.51,64.97 222.96,64.97 223.14,64.8 223.14,64.11 223.47,63.78 224.59,63.78 224.89,64.09 224.89,65 225,65.1 225.5,65.1 225.58,65.03 225.58,63.43 225.25,63.09
3D3V_S0 on BOTTOM: 156.2,102.84 155.6,103.43 155.6,103.73 155.93,104.06 155.93,104.42 156.2,104.7 156.8,104.7 156.87,104.62 156.87,103.94 157.41,103.4 157.41,102.94 157.31,102.84 ; 1 cut-out
3D3V_S0 on BOTTOM: 128.02,102.57 127.79,102.8 127.05,102.8 126.5,103.35 126.5,104.95 126.62,105.08 128.37,105.08 128.43,105.03 128.43,102.62 128.37,102.57 ; 3 cut-outs
3D3V_S0 on BOTTOM: 129.19,95.61 128.91,95.89 128.91,96.85 129.04,96.98 129.85,96.98 130.48,96.34 130.48,95.96 130.13,95.61
3D3V_S0 on BOTTOM: 42.6,27.43 42.24,27.79 42.24,30.66 42.27,30.68 42.68,30.68 43.82,29.54 80.32,29.54 80.65,29.87 80.65,31.6 80.7,31.65 81.38,31.65 81.46,31.57 81.46,29.87 81.79,29.54 91.87,29.54 92.15,29.26 92.15,28.02 91.57,27.43 ; 2 cut-outs
3D3V_S0 on BOTTOM: 161.01,80.57 160.79,80.8 160.79,81.41 160.61,81.59 160.15,81.59 160.02,81.71 160.02,82.32 160.3,82.6 161.85,82.6 161.85,80.65 161.78,80.57 ; 1 cut-out
3D3V_S0 on BOTTOM: 196.09,35.23 195.84,35.49 195.84,37.29 196.14,37.59 196.14,39.04 196.95,39.04 196.95,38.1 197.26,37.8 197.28,37.8 197.49,37.59 197.49,35.36 197.36,35.23
3D3V_S0 on BOTTOM: 202.52,57.51 202.34,57.68 202.34,57.89 202.52,58.07 202.7,58.07 202.8,58.17 202.8,59.59 203.51,59.59 203.61,59.49 203.61,57.84 203.28,57.51
3D3V_S0 on BOTTOM: 43.49,113.31 43.21,113.59 43.21,116.13 42.19,117.15 42.19,120.73 42.37,120.73 44.83,123.19 44.83,125.5 42.9,127.43 42.9,131.47 43.41,131.98 47.37,131.98 47.6,131.75 47.6,128.37 49.56,126.42 49.56,125.17 49.81,124.92 51.18,124.92 51.74,124.36 51.74,118.24 52.1,117.88 53.8,117.88 56.72,120.8 56.98,120.8 57.15,120.63 57.15,120.4 57,120.24 57,119.89 57.58,119.31 57.58,119.08 56.07,117.57 56.07,115.98 55.9,115.8 53.27,115.8 52.48,115.01 49.53,115.01 47.86,113.34 43.84,113.34 43.82,113.31 ; 8 cut-outs
3D3V_S0 on BOTTOM: 106.66,140.26 106.45,140.46 106.45,140.92 106.56,141.02 108.03,141.02 108.16,140.9 108.16,140.41 108,140.26
3D3V_S0 on L2GND: 90.63,27.29 90.11,27.82 90.11,29.95 91.01,30.85 106.13,30.85 106.51,31.23 111.05,31.23 112.57,29.71 112.95,29.71 113.48,29.18 113.48,28.8 113.97,28.31 116.92,28.31 117.8,29.18 117.8,31.22 118.3,31.72 118.3,32.99 119.72,34.41 128.48,34.41 128.61,34.53 131.65,34.53 131.91,34.79 133.27,34.79 133.53,34.53 152.2,34.53 152.57,34.16 152.57,33.27 153.21,32.63 170.52,32.63 171.79,33.9 182.33,33.9 182.96,34.53 191.57,34.53 192.96,33.14 196.04,33.14 196.41,33.5 196.41,34.42 196.03,34.8 196.03,35.66 196.3,35.93 197.92,35.93 199.08,34.77 199.08,31.88 198.55,31.36 128.86,31.36 126.83,33.39 124.51,33.39 122.75,31.63 122.75,27.94 122.1,27.29
3D3V_S0 on L2GND: 175.47,52.31 175.2,52.58 175.2,59.66 176.6,61.06 176.6,64.14 174.83,65.9 172.55,65.9 166.83,71.62 166.33,71.62 165.93,72.01 165.93,72.9 165.42,73.41 165.42,73.9 165.71,74.28 167.95,74.28 170.63,71.6 170.63,70.2 172.9,67.93 175.31,67.93 178.88,64.36 178.88,60.2 177.49,58.81 177.49,55.73 178.37,54.84 178.37,54.61 177.49,53.73 177.49,52.71 177.09,52.31
3D3V_S0 on L3: 53.8,75.95 53.8,55.88 49.86,51.94 36.05,51.94 33.61,49.51 33.61,44.3 34.37,43.54 73.66,43.54 74.07,43.94 95.74,43.94 95.79,43.89 95.79,43.49 95.15,42.85 93.96,42.85 92.99,41.89 78.84,41.89 77.14,40.18 70.13,40.18 69.14,39.19 51.9,39.19 51.31,39.78 43.46,39.78 42.88,39.19 33.2,39.19 27.69,44.71 27.69,48.29 32.35,52.95 32.35,53.68 32.83,54.17 33.57,54.17 35.21,55.81 47.4,55.81 49,57.41 49,78.77 50.98,80.75 50.98,91.44 47.86,94.57 47.86,96.57 41.28,103.15 41.28,116.59 42.4,117.7 44.91,117.7 48.26,114.35 48.26,112.75 48.85,112.17 48.85,106.22 54,101.07 54,95.84 54.84,95 54.84,92.46 57.13,90.17 57.13,80.72 57.11,80.71 57.11,79.26 ; 1 cut-out
3D3V_S0 on L5: 117.68,29.87 118.54,29.87 121.07,32.4 121.07,35.65 122.43,37.01 126.22,37.01 127.49,35.74 127.49,35.15 129.71,32.93 130.98,32.93 131.91,32.01 131.91,31.47 131.68,31.24 128.53,31.24 127.17,32.6 123.99,32.6 122.72,31.33 122.72,29.73 120.03,27.04 112.89,27.04 112.55,27.38 109.12,27.38 108.77,27.74 108.77,29.06 109.55,29.85 113.64,29.85 113.99,29.5 113.99,28.64 114.15,28.47 116.28,28.47
3D3V_S0 on L5: 103.76,146.81 102.72,146.81 101.4,145.49 101.4,142.37 102.24,141.53 103.08,141.53 103.25,141.71 103.25,145.44 103.89,146.08 103.89,146.69
3D3V_S0 on L6: 165.74,73.71 165.48,73.97 165.48,74.35 164.2,75.63 163.62,75.63 161.22,78.03 159.52,78.03 159.16,77.67 152.68,77.67 152.58,77.57 152.58,77.55 152.17,77.14 148.06,77.14 147.15,78.06 144.28,78.06 142.78,79.55 142.34,79.55 141.91,79.12 138.81,79.12 136.17,81.76 136.17,90.88 137.39,92.1 137.39,96.62 136.78,97.23 136.78,97.99 136.86,98.07 138.76,98.07 139.93,96.9 139.93,90.07 138.08,88.22 138.08,83.34 138.53,82.88 142.75,82.88 143.27,82.36 144.44,82.36 145.01,81.79 147.91,81.79 150.29,79.4 151.41,79.4 152.25,80.24 157.15,80.24 157.71,79.68 158.47,79.68 158.98,80.19 162.31,80.19 163.2,79.3 163.71,79.3 167.14,75.87 167.14,73.84 167.01,73.71
3D3V_S5 on TOP: 155.16,53.01 148.94,59.23 148.94,64.23 149.53,64.82 149.53,65.08 149.91,65.46 151.39,65.46 152.78,64.06 152.78,60.5 157.14,56.15 169.71,56.15 173.26,59.69 175.62,59.69 176.15,60.22 182.43,60.22 182.73,59.92 188.29,59.92 190.81,62.43 200.79,62.43 201.04,62.18 201.91,62.18 202.95,61.14 202.95,59.62 202.57,59.23 193.4,59.23 190.71,56.54 179.2,56.54 177.23,54.57 176.42,54.57 176.23,54.76 175.3,54.76 175.11,54.57 172.61,54.57 171.05,53.01 ; 3 cut-outs
3D3V_S5 on TOP: 18.16,67.29 17.94,67.51 17.94,69.34 17.35,69.93 17.35,70.59 17.53,70.77 17.94,70.77 18.88,69.83 18.88,69.04 19.03,68.89 19.97,68.89 20.07,68.78 20.07,67.44 19.92,67.29 ; 3 cut-outs
3D3V_S5 on TOP: 96.93,30.91 96.68,31.17 94.08,31.17 93.86,31.4 93.86,31.84 94.16,32.14 96.87,32.14 97.62,32.89 98.25,32.89 100.76,35.41 100.76,36.2 100.65,36.31 99.91,36.31 99.42,36.81 99.42,38.43 99.7,38.71 99.7,40.12 100.56,40.98 102.38,40.98 103.15,41.76 103.36,41.76 103.81,41.3 103.81,40.23 103.36,39.78 102.34,39.78 102.09,39.52 102.09,39.14 102.11,39.12 102.11,38.06 103.14,37.03 103.14,35.37 99.81,32.04 99.05,32.04 98.91,31.9 98.91,31.17 98.66,30.91 ; 2 cut-outs
3D3V_S5 on TOP: 216.39,45.34 215.93,45.8 215.93,47.88 216.3,48.25 218.25,48.25 218.32,48.19 218.32,46.58 218.11,46.38 218.11,45.44 218.01,45.34 ; 2 cut-outs
3D3V_S5 on TOP: 48.14,100.97 47.87,101.23 47.87,102.76 47.68,102.95 47.3,102.95 47.21,103.04 47.22,103.05 47.22,103.91 47.5,104.19 48.77,104.19 49.53,104.95 51.57,104.95 52.2,104.32 53.98,104.32 54.74,103.56 54.74,101.53 54.18,100.97 ; 2 cut-outs
3D3V_S5 on TOP: 55.48,125.5 55.4,125.58 55.4,126.62 55.17,126.85 54.79,126.85 54.79,127.86 53.88,128.78 53.88,130.07 53.94,130.14 54.52,130.14 54.71,130.33 58.19,130.33 58.42,130.1 58.42,126.14 57.79,125.5 ; 5 cut-outs
3D3V_S5 on TOP: 47.53,130.4 47.3,130.63 47.3,131.75 47.32,131.78 47.91,131.78 48.06,131.62 48.57,131.62 49.05,132.11 49.05,132.74 48.62,133.17 47.32,133.17 47.25,133.25 47.25,134.14 47.35,134.24 50.27,134.24 50.37,134.14 50.47,134.14 50.93,133.68 50.93,131.8 49.53,130.4
3D3V_S5 on BOTTOM: 52.01,124.96 50.55,126.42 49.84,126.42 48.01,128.25 48.01,131.34 47.76,131.6 47.76,131.85 47.35,132.26 47.35,133.73 47.58,133.96 50.78,133.96 51.03,133.71 51.03,130.51 51.31,130.23 52.33,130.23 52.34,130.24 52.35,130.23 53.04,130.23 53.55,130.74 57.41,130.74 57.71,130.43 57.71,128.7 57.58,128.58 56.9,128.58 56.77,128.45 56.77,125.34 56.39,124.96 ; 4 cut-outs
3D3V_S5 on BOTTOM: 93.78,34.57 93.73,34.62 93.73,38.41 94.19,38.86 99.62,38.86 100.08,38.41 100.08,36.63 99.6,36.15 98.76,36.15 98.63,36.27 98.63,36.83 99.27,37.47 99.27,37.72 99.09,37.9 97.03,37.9 96.83,37.69 96.83,34.67 96.73,34.57 ; 1 cut-out
3D3V_S5 on BOTTOM: outline of 82 points within 32.5,40.64 152.28,94.29 ; 2 cut-outs
3D3V_S5 on BOTTOM: 208.84,49.4 208.66,49.58 208.66,51.03 208.79,51.16 210.19,51.16 210.39,50.95 210.39,49.53 210.26,49.4
